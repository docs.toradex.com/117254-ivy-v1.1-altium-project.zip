# Altium PCB 46806005.~(3).PcbDoc (part 4 of 9)
Units mm, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 130 x 105 mm, 8 copper layers (Top Layer, P1-GND, L1-Signal, L2-Signal, L3-Signal, L4-Signal, P2-GND, Bottom Layer), stack 1.63 mm thick; 795 components, 496 nets, 2816 pads, 1210 vias.
Unrouted connection lines stored in the file: 1.

## Via types
v1: diameter 0.6, hole 0.3, Top Layer to Bottom Layer, tented both sides, 1145 vias
v2: diameter 0.6, hole 0.3, Top Layer to Bottom Layer, 65 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
3V3: C62.2 C63.2 C83.2 C86.2 C88.2 C89.2 C91.2 C114.2 C207.2 C208.2 C209.2 C213.2 C219.1 C220.1 C228.1 C229.1 C251.2 J2.3 J7.11 J7.13 J10.11 J10.13 J15.25 L5.1 L6.1 L11.2 L26.1 L27.1 L28.1 L31.1 L33.1 Q13.1 R12.1 R13.1 R14.2 R15.2 R16.2 R17.1 R18.1 R36.2 R53.2 R98.1 R99.1 R100.1 R101.1 R102.1 R103.1 R104.1 R105.1 R180.2 R181.2 R182.1 R249.2 R263.2 R270.1 R271.1 RA2.1 RA2.2 RA2.3 RA2.4 U8.28 U16.22 U16.23 U43.1 U45.1 U48.22 U48.23 U50.1 U51.1 U54.1 U55.1 X17.1 | length 84
  Top Layer w0.15: v1(20.3,8.45) R263.2@21.2,8.45 ; C114.2@42.45,39.5 C114.2@42.5,39.45 ; U16.23@42.575,40.825 U16.23@42.6,40.8 ; C83.2@89.023,66.95 89.023,65.821 R36.2@89.048,65.796
  Top Layer w0.2: U16.22@41.95,40.825 U16.23@42.575,40.825 ; C114.2@42.45,39.5 42.45,40 42.6,40.15 U16.23@42.6,40.8
  Top Layer w0.25: v1(5.8,53.6) R53.2@6.5,53.6 ; J15.25@6.881,87.478 v1(8.05,87.478) 8.144,87.478 8.269,87.603 8.725,87.603 C251.2@8.85,87.728 ; C63.2@34.873,24.025 34.873,24.556 v1(35.265,24.947) 35.265,24.853 35.548,24.569 35.548,24.15 C62.2@35.673,24.025 ; C62.2@35.679,24.03 35.697,24.012 36.405,24.012 v1(36.417,24) ; RA2.1@36.6,36.35 RA2.2@37.4,36.35 RA2.3@38.2,36.35 RA2.4@39,36.35 v1(39,35.45) ; R36.2@89.051,65.799 89.35,65.5 v1(90.05,65.5)
  Top Layer w0.3: Q13.1@19.15,8.45 v1(20.3,8.45)
  Top Layer w0.4: v1(42.5,38.7) C114.2@42.5,39.45
  Top Layer w0.5: v1(16.63,31.05) 18.554,31.05 18.803,31.3 20.75,31.3 21.983,30.067 L5.1@21.983,28.774 ; v1(91,69.8) C88.2@92.65,69.8 ; v1(91,71.4) C86.2@92.65,71.4 ; v1(91.1,76.65) C89.2@92.75,76.65 ; v1(91.1,78.25) C91.2@92.75,78.25 ; v1(94.322,37.322) C220.1@94.322,36.585 96.175,36.585 U51.1@96.191,36.568 ; C219.1@94.422,30.785 96.184,30.785 U50.1@96.191,30.792 95.992,30.792 95.8,30.985 v1(95.8,31.7) ; v1(95.639,50.339) 95.658,50.32 95.739,50.32 95.96,50.1 C228.1@96.3,50.1 ; v1(95.883,43.825) 95.788,43.825 95.689,43.924 C229.1@94.594,43.924 94.594,43.306 94.966,42.934 U54.1@96.347,42.934 ; C228.1@96.3,50.05 C228.1@96.3,50.1 ; U55.1@96.37,48.734 96.3,48.804 C228.1@96.3,50.1
  Top Layer w0.75: L28.1@33.54,53.654 v1(34.365,53.654) ; L27.1@33.54,55.054 33.575,55.019 34.222,55.019 34.391,54.85 v1(34.45,54.85)
  Top Layer w0.9: L6.1@33.65,48.68 v1(33.65,49.58)
  L2-Signal w0.2: 55.265,51.385 55.3,51.35
  L2-Signal w0.6: 55.265,51.385 J2.3@55.265,52.505
  Bottom Layer w0.15: v1(20.5,15.35) R16.2@21.25,15.35 ; R182.1@84.45,48.545 84.45,49.795 C209.2@84.5,49.845 R181.2@84.5,50.745 R180.2@84.5,51.745
  Bottom Layer w0.2: U8.28@34.459,24.947 v1(35.265,24.947) ; v1(61.35,61.4) 61.35,61.3 61.5,61.15 61.5,60.75 C213.2@61.45,60.7 63.025,60.7 63.275,60.45 U48.23@63.975,60.45 64,60.425 U48.22@64,59.8
  Bottom Layer w0.25: v1(11.135,96.15) L33.1@12.035,96.15 ; v1(27.1,73.3) 28.1,73.3 R270.1@28.2,73.4 ; v1(27.6,76.15) 27.9,76.15 R271.1@28.4,75.65 ; v1(36.1,18.95) R14.2@36.1,19.7 ; v1(37.05,18.95) R15.2@37.05,19.7 ; R17.1@37.45,25.35 R18.1@37.45,26.25 R13.1@37.45,27.15 R12.1@37.45,28.05 v1(38.2,28.05) ; v1(60.2,80.25) R103.1@61.197,80.249 ; v1(60.2,85.55) R104.1@61.197,85.549 ; v1(60.2,91.15) 61.196,91.15 R105.1@61.197,91.149 ; v1(60.3,74.85) R102.1@61.296,74.85 ; R180.2@84.5,51.745 v1(84.5,52.45)
  Bottom Layer w0.3: R103.1@61.197,80.249 R99.1@61.197,81.849 ; R104.1@61.197,85.549 R100.1@61.197,87.149 ; R105.1@61.197,91.149 R101.1@61.197,92.749 ; R102.1@61.297,74.849 R98.1@61.297,76.449
  Bottom Layer w0.5: L31.1@15.59,31.05 v1(16.63,31.05) ; v1(61.775,28.9) 62.75,28.9 L26.1@62.76,28.91 ; v1(91.267,53.917) 91.284,53.901 91.284,53.016 C207.2@91.3,53 U43.1@93.432,53 ; U45.1@93.45,76.308 93.5,76.258 C208.2@93.5,74.853 v1@94.212,74.853 ; v1(95.883,43.825) 95.883,43.798 95.85,43.765 95.85,43.168 96.95,42.068 97.25,42.068 97.5,41.818 R249.2@97.5,41.518
  other v1: 94.213,74.854
5V: C3.1 C61.2 C67.1 C87.2 C92.2 C93.2 C94.2 C95.2 C96.2 C98.2 C99.2 C210.1 C211.1 C212.2 C214.2 C217.2 C218.1 C226.2 C227.1 D5.1 D7.1 D8.1 D9.1 J2.4 L1.1 L13.2 L14.2 L15.1 L16.1 L24.1 L34.1 L40.1 R39.2 R44.2 R50.2 R51.2 R59.2 R125.2 R126.2 R138.2 R177.2 R179.2 R187.2 R191.2 R211.2 R243.2 R255.1 R261.1 U8.18 U9.2 U9.4 U44.1 U44.3 U46.1 U46.3 U49.1 U49.3 U53.1 U53.3 X18.1 | length 134.7
  Top Layer w0.25: v1(1.1,53.613) R51.2@1.8,53.613 ; v1(6.6,19.5) 7.578,19.5 D5.1@7.648,19.571 ; D7.1@9.45,9.275 v1(10.394,9.275) ; D8.1@9.45,13.825 v1(10.394,13.825) ; D9.1@9.45,22.925 v1(10.394,22.925) ; R138.2@40.865,50.77 v1(41.795,50.77) ; v1(49.502,98.5) R50.2@49.502,99.2 ; v1(55.6,30.05) 56.15,30.05 C87.2@56.9,30.8 57.35,30.8 58.05,30.8 R39.2@58.15,30.7 ; v1(66.1,32.525) C95.2@66.1,33.575 ; v1(68.4,32.525) C94.2@68.4,33.575 ; v1(71.05,34) C92.2@72.1,34 ; v1(71.075,26.5) C96.2@72.125,26.5 ; v1(71.075,31.5) C99.2@72.125,31.5 ; R44.2@86.875,41.803 R44.2@86.9,41.828 ; X18.1@87.075,40.007 R44.2@87.075,41.775 ; v1(87.15,49.85) C3.1@87.15,51.5 ; C93.2@89.675,47.4 v1(90.65,47.4)
  Top Layer w0.5: U9.2@32.735,42.05 32.75,42.065 32.75,43.285 v1(32.765,43.3) ; L13.2@69.45,29 v1(71.075,29) C98.2@72.125,29 ; v1(94.831,66.759) 96.696,66.759 R255.1@96.7,66.763 ; v1@94.834,90.049 R261.1@96.6,90.049
  Top Layer w0.55: L24.1@102.952,11.352 v1(103.91,11.352)
  Top Layer w0.75: C61.2@28.1,42.075 v1@29.34,42.075 ; v1(29.365,42.1) 30.145,42.1 U9.4@30.195,42.05
  Top Layer w1: C67.1@90.35,79.9 v1(91.425,79.9)
  L4-Signal w0.15: 54.42,54.503 55.148,53.775 J2.4@55.265,53.775
  L4-Signal w0.25: v1(49.502,98.5) 49.502,97.798 50.35,96.95 73.1,96.95 76.8,100.65 92.4,100.65 93.4,99.65 93.4,93.8 92.152,92.552 v1(89.887,92.552)
  L4-Signal w0.6: J2.4@55.265,53.775 55.535,54.045 55.535,54.189 56.011,54.665
  Bottom Layer w0.15: C212.2@91.464,66.758 91.75,67.044 R177.2@91.75,68.3
  Bottom Layer w0.2: U8.18@34.459,28.947 34.761,28.947 35.113,29.3 35.928,29.3 36.128,29.1 v1(37.05,29.1)
  Bottom Layer w0.25: L16.1@19.74,47.2 19.99,46.95 20.04,47 v1(20.6,47) ; R59.2@19.9,51.4 v1(20.9,51.4) ; v1(37.05,29.1) R211.2@37.05,29.95 ; v1(61.45,25.15) R125.2@61.45,25.9 ; R126.2@68.825,25.95 68.838,25.938 68.838,25.212 v1(68.85,25.2) ; v1(89.887,92.552) R179.2@90.6,92.553 ; v1@90.788,44.607 R191.2@91.5,44.607 ; v1@90.81,32.723 R187.2@91.522,32.723 ; C218.1@91.95,30.25 92.758,30.25 v1(92.791,30.217)
  Bottom Layer w0.5: L34.1@1.05,96.68 v1(1.05,97.59) ; v1(91.4,63.45) C210.1@91.4,64.2 ; C212.2@91.464,66.758 U44.3@93.45,66.758 v1(94.831,66.759) ; C210.1@91.522,64.2 92.1,64.2 92.109,64.209 93.441,64.209 U44.1@93.45,64.218 ; v1(91.599,88.266) 91.599,88.751 91.325,89.025 C214.2@91.325,90.053 91.33,90.048 U46.3@93.45,90.048 ; v1@91.6,88.265 C211.1@91.6,87.553 91.645,87.508 U46.1@93.45,87.508 ; C217.2@92.025,27.7 C217.2@92.047,27.678 ; v1(92.05,28.95) 92.047,28.947 C217.2@92.047,27.678 ; v1(92.35,38.2) 92.325,38.225 C226.2@92.325,39.468 92.38,39.523 U53.1@94.35,39.523 ; v1(92.46,41.343) 92.48,41.363 92.48,41.987 C227.1@92.5,42.007 93.644,42.007 93.7,42.063 U53.3@94.35,42.063 ; v1@92.792,30.218 U49.3@94.172,30.218 95.518,30.218 96.57,31.27 97.25,31.27 97.5,31.52 R243.2@97.5,31.7 ; U46.3@93.452,90.05 v1@94.829,90.05 ; U49.1@94.172,27.678 C217.2@92.047,27.678
  Bottom Layer w0.75: L15.1@8.85,33.79 8.88,33.79 8.965,33.875 8.965,34.365 9.082,34.482 v1(9.082,34.8) ; L1.1@18.95,24.89 L40.1@20.311,24.89 v1(20.311,25.93)
  other v1: 71.075,27.45 71.075,29.95 67.05,31.575 68.4,31.575 69.35,31.575 71.075,32.45 67.05,32.525 69.35,32.525 90.809,32.721 8.441,34.801 90.787,44.605 90.15,46.05 91.25,46.05 90.65,46.65 87.9,49.85 94.831,90.052
5V_485: C221.1 C222.1 C223.1 C224.2 C225.1 R243.1 U49.13 U49.14 U50.8 U51.8 U52.8 X69.1 | length 24.6
  Top Layer w0.25: C222.1@103.517,36.568 C222.1@103.522,36.563
  Top Layer w0.5: U50.8@101.652,30.792 102.859,30.792 103.288,31.221 103.288,31.738 C221.1@103.3,31.75 105.248,31.75 X69.1@106.448,32.95 ; U51.8@101.652,36.568 C222.1@103.517,36.568 ; C222.1@103.522,36.563 104.205,36.563 104.81,37.168 105.607,37.168 105.881,36.894 105.881,36.019 v1(105.9,36) ; v1(107.913,34.078) 107.913,33.398 107.981,33.33 U52.8@109.145,33.33
  Bottom Layer w0.5: R243.1@100.7,31.7 102,31.7 102.2,31.5 103.66,31.5 U49.13@103.672,31.488 105.474,31.488 ; U49.14@103.672,30.218 103.68,30.225 104.975,30.225 105.474,30.724 105.474,31.488 ; v1(105.9,36) C224.2@106.975,36 ; X69.1@106.448,32.95 C223.1@106.45,31.488 105.474,31.488
5V_AIN1: C200.2 C205.1 R255.2 U41.1 U41.3 U44.13 U44.14 | length 17.8
  Top Layer w0.5: v1(101.569,66.757) 99.906,66.757 R255.2@99.9,66.763 99.9,67.063 100.845,68.008 101.55,68.008 v1(101.569,68.027)
  Bottom Layer w0.5: v1@101.57,66.758 U44.14@102.95,66.758 104.24,66.758 104.307,66.69 C205.1@104.757,66.69 ; v1(101.569,68.027) U44.13@102.949,68.027 ; U44.13@102.95,68.028 104.77,68.028 105.094,68.353 105.094,69.272 105.59,69.767 U41.1@105.59,70.852 105.59,70.877 106.497,70.877 106.86,71.24 106.86,72.64 106.591,72.909 U41.3@105.59,72.909
5V_AIN2: C202.2 C206.1 R261.2 U42.1 U42.3 U46.13 U46.14 | length 17.9
  Top Layer w0.5: v1(101.55,90.046) 99.807,90.046 R261.2@99.8,90.053 99.8,90.353 100.763,91.316 v1(101.55,91.316)
  Bottom Layer w0.5: v1@101.551,90.047 U46.14@102.931,90.047 ; v1@101.551,91.317 U46.13@102.931,91.317 ; U46.14@102.95,90.048 102.952,90.05 104.697,90.05 C206.1@104.7,90.053 ; U46.13@102.95,91.318 104.64,91.318 105.035,91.713 105.035,92.632 105.53,93.127 U42.1@105.53,94.237 106.437,94.237 106.8,94.6 106.8,96 106.531,96.269 U42.3@105.53,96.269
5V_CAN: C115.2 C116.2 C117.1 C118.1 L24.2 R86.2 R87.2 R233.2 R237.1 U18.1 U18.3 U19.1 U19.3 | length 49.3
  Top Layer w0.15: L24.2@102.95,9.77 104.55,9.77 105,9.32 R86.2@105,8.81
  Top Layer w0.25: L24.2@102.95,9.77 L24.2@102.952,9.768
  Top Layer w0.5: C116.2@92.425,15.9 92.425,17.175 92.881,17.631 92.931,17.631 v1(92.95,17.65) ; v1(102.952,8.81) L24.2@102.952,9.768 ; v1(104.069,2.714) 105.271,2.714 C115.2@105.275,2.71
  L3-Signal w0.5: v1(90.25,20.4) 91.55,19.1 91.55,18.3 91.843,18.007 92.566,18.007 92.923,17.65 v1(92.95,17.65) ; v1(102.952,8.81) 102.2,8.058 102.2,7.25 102.85,6.6 102.85,5.2 ; v1@104.042,2.714 103.536,2.714 102.5,3.75 102.5,4.85 102.85,5.2 ; v1(104.05,5.3) 104.031,5.281 102.931,5.281 102.85,5.2
  Bottom Layer w0.15: v1(90.25,20.4) R87.2@91,20.4
  Bottom Layer w0.5: C118.1@92.2,17.7 92.873,17.7 92.923,17.65 v1(92.95,17.65) ; R237.1@97.5,19.6 97.5,19.3 97.25,19.05 96.45,19.05 96.15,18.75 96.15,18.15 95.7,17.7 94.355,17.7 U19.3@94.35,17.695 94.324,17.669 92.969,17.669 v1(92.95,17.65) ; v1(102.952,8.81) 101.59,8.81 95.75,14.65 v1(95.75,15.15) 95.747,15.152 94.353,15.152 94.3,15.205 93.65,15.205 92.903,15.952 92.903,17.576 92.95,17.623 v1(92.95,17.65) ; C117.1@103.3,5.32 103.31,5.31 104.04,5.31 v1(104.05,5.3) 104.052,5.298 105.392,5.298 U18.3@105.395,5.3 ; v1(104.069,2.714) 108.555,2.715 R233.2@108.6,2.76
5V_CAN1: C121.1 C124.2 C125.2 C129.1 R92.2 R233.1 U18.13 U18.14 U20.8 U22.3 X30.1 | length 16.1
  Top Layer w0.5: U20.8@112.28,9.065 114.094,9.065 C129.1@114.1,9.06 ; C129.1@114.1,9.1 115.9,9.1 v1(116.35,9.55) ; U22.3@114.918,2.738 114.96,2.78 116.33,2.78 v1(116.35,2.8)
  Bottom Layer w0.5: R233.1@111.8,2.76 111.84,2.8 v1(112.675,2.8) ; U18.13@114.95,6.525 114.96,6.515 116.041,6.515 116.478,6.078 v1(116.478,5.3) ; U18.14@114.955,5.3 114.958,5.298 116.475,5.298 v1(116.478,5.3) ; C121.1@117.15,5.3 v1(116.478,5.3) ; C121.1@117.15,5.315 118.335,5.315 120.728,5.315 R92.2@121.567,4.476
5V_CAN2: C122.1 C123.2 C126.2 C130.1 R93.2 R237.2 U19.13 U19.14 U21.8 U23.3 X31.1 | length 15.7
  Top Layer w0.25: U23.3@103.8,17.66 103.818,17.678 105.213,17.678 v1(105.231,17.696)
  Top Layer w0.5: U21.8@101.181,21.505 102.995,21.505 C130.1@103,21.5 104.767,21.5 105.117,21.85 105.888,21.85 R93.2@105.9,21.862 105.85,21.812 v1(105.85,20.9)
  Bottom Layer w0.5: R237.2@100.7,19.6 102.497,19.6 v1(102.498,19.599) ; v1@102.5,19.6 102.5,19.57 102.565,19.505 102.565,19.422 102.972,19.015 103.783,19.015 U19.13@103.85,18.948 ; U19.14@103.85,17.695 v1(105.231,17.696) ; v1(105.231,17.696) C126.2@107.579,17.696 ; v1(107.55,18.8) 107.55,17.725 C126.2@107.579,17.696 ; C126.2@107.6,17.675 C126.2@107.579,17.696
+V5_SW: C240.2 C243.2 C244.2 C246.2 C248.2 C250.2 C252.2 J15.26 J15.27 J15.28 J15.29 U64.6 U65.2 U65.4 X81.1 | length 44
  Top Layer w0.25: J15.27@6.881,88.478 v1(8.05,88.478) ; J15.29@6.881,89.478 v1(8.05,89.478)
  Top Layer w0.4: v1(2.913,87.978) J15.26@4.081,87.978 ; v1(2.913,88.978) J15.28@4.081,88.978
  Top Layer w0.5: v1(6.7,94.378) 9.05,96.728 9.05,97.233 10.117,98.3 13.695,98.3 v1(15.72,100.325)
  Bottom Layer w0.15: v1(15.72,100.325) 15.195,100.85 10.55,100.85 9.7,100 9.7,96.5 10.9,95.3 14.2,95.3 14.5,95.6 14.5,96.041 15.373,96.915 U65.2@15.725,96.915
  Bottom Layer w0.25: C244.2@5.05,93.528 6.7,93.528 ; U64.6@6.7,95.073 U64.6@6.705,95.078
  Bottom Layer w0.5: U64.6@6.7,95.073 v1(6.7,94.378) 6.7,93.528 6.7,92.15 6.735,92.115 6.735,91.24 7.027,90.947 8.08,90.947 v1(8.1,90.928) ; C240.2@13.55,99.45 U65.4@15.72,99.45 ; v1(15.72,100.325) U65.4@15.72,99.45 ; U65.4@15.725,99.455 U65.4@15.72,99.45
  other v1: 8.1,90.128
ADC.ADC1: C97.1 M1.2 R48.1 R49.2 | length 102
  Top Layer w0.15: v1(12.5,64.353) M1.2@12.5,65.6 ; R49.2@81.8,17.5 R48.1@81.8,16.25 C97.1@83.15,16.25
  Top Layer w0.25: R49.2@81.8,17.65 v1(81.8,18.4)
  L2-Signal w0.15: v1(12.5,64.353) 12.5,60.592 12.625,60.467 12.625,53.883 15.733,50.775 19.253,50.775 26.4,43.628 26.4,41.05 40.525,26.925 40.525,26.21 47.993,18.742 54.792,18.742 55.1,19.05 55.108,19.05 55.183,19.125 55.892,19.125 56.275,18.742 64.667,18.742 65.45,19.525 80.675,19.525 v1(81.8,18.4) ; v1@81.725,18.325 v1@81.8,18.25
ADC.ADC2: C100.1 M1.4 R51.1 R52.2 | length 24.9
  Top Layer w0.15: R51.1@2.8,53.613 C100.1@3.8,53.613 ; R52.2@3.8,54.713 C100.1@3.8,53.613 ; M1.4@13,65.6 13,66.65 12.7,66.95 10.75,66.95 9.65,65.85 9.65,56.2 8.35,54.9 8.35,53.532 7.893,53.075 4.47,53.075 4.275,53.27 4.275,53.311 4.148,53.438 3.975,53.438 C100.1@3.8,53.613
ADC.ADC3: C101.1 M1.6 R53.1 R54.2 | length 19.6
  Top Layer w0.15: R53.1@7.5,53.6 R54.2@7.5,54.5 C101.1@7.5,55.3 8.25,55.3 9.35,56.4 9.35,65.976 10.624,67.25 12.993,67.25 13.5,66.743 M1.6@13.5,65.6
ADC.ADC4: C103.1 M1.8 R56.1 R57.2 | length 18
  Top Layer w0.15: R57.2@7.5,56.2 C103.1@7.5,57.1 R56.1@7.5,58 8.25,58 9.05,58.8 9.05,66.1 10.5,67.55 13.239,67.55 14,66.789 M1.8@14,65.6
AIN1+: D24.1 J5.2 RA6.2 U37.4 | length 18.1
  Bottom Layer w0.15: RA6.2@111.3,61.3 111.85,61.3 112.1,61.05 112.1,60.3 112.4,60 114.095,60 114.561,59.534 115.975,59.534
  Bottom Layer w0.25: D24.1@113.1,64.685 114.843,64.685 115.975,63.553 115.975,59.534 U37.4@115.975,57.727 116.727,57.727 117,58 J5.2@118.9,58
AIN1-: D24.2 J5.1 PTC5.1 | length 27.3
  Top Layer w0.25: PTC5.1@112.116,61 112.116,64.516 113.1,65.5 v1(113.1,67.6) ; v1(114.6,68.7) 115.531,67.769 115.531,60.29 117.1,58.721 117.1,57.376 117.876,56.6 120,56.6 J5.1@121.4,58
  Bottom Layer w0.25: v1(113.1,67.6) 113.054,67.646 D24.2@113.054,68.733 113.087,68.7 v1(114.6,68.7)
AIN1_DRDY_3V3: R253.1 U43.7 U48.16 | length 39.3
  Top Layer w0.15: v1(94.831,60.639) 95.455,61.263 R253.1@96.6,61.263
  Bottom Layer w0.15: U48.16@66.4,59.95 66.4,59.35 67,58.75 68.1,58.75 70.75,61.4 70.75,62.7 69.45,64 69.45,64.576 69.724,64.85 81.1,64.85 82.35,63.6 87,63.6 89.962,60.638 U43.7@93.45,60.638
  Bottom Layer w0.25: U43.7@93.45,60.638 v1@94.83,60.638
AIN1_DRDY_ISO: R172.1 R253.2 U39.14 U43.10 | length 13.5
  Top Layer w0.15: R253.2@99.8,61.263 103.727,61.263 v1(104.35,60.64)
  Bottom Layer w0.15: U43.10@102.969,60.639 v1@104.349,60.639 ; v1(104.35,60.64) 104.445,60.64 104.755,60.95 108.079,60.95 108.225,61.096 U39.14@108.225,62.25 108.284,62.309 108.284,63.184 108.65,63.55 R172.1@108.65,64.2
AIN1_MODE_3V3: R254.1 U43.4 U48.20 | length 46.5
  Top Layer w0.25: v1(94.831,56.829) 96.566,56.829 R254.1@96.6,56.863
  L2-Signal w0.15: v1(63.491,58.767) 63.564,58.84 63.564,62.114 65.937,64.487 68.963,64.487 v1(71.358,62.092)
  Bottom Layer w0.15: v1(63.491,58.767) 63.544,58.714 64.239,58.714 64.8,59.274 U48.20@64.8,59.95 ; v1(71.358,62.092) 71.358,62.958 72.2,63.8 75.05,63.8 75.8,64.55 80.976,64.55 82.226,63.3 86.876,63.3 90.55,59.626 90.55,57.65 91.3,56.9 93.378,56.9 U43.4@93.45,56.828
  Bottom Layer w0.25: U43.4@93.45,56.828 v1@94.83,56.828
AIN1_MODE_ISO: Q9.2 Q9.5 R175.2 R254.2 U43.13 X62.1 | length 27.3
  Top Layer w0.15: R254.2@99.8,56.863 99.833,56.83 v1(104.35,56.83)
  Bottom Layer w0.15: v1(104.35,56.83) 104.35,57.624 104.876,58.15 108.352,58.15 109.202,59 110.415,59 ; Q9.2@111.05,59 110.415,59 ; X62.1@116.6,53.5 116.6,56.1 115.85,56.85 113.15,56.85 112.776,57.224 112.776,58.176 R175.2@113.6,59 Q9.5@112.4,59 112.325,59.075 112.15,59.075 112.1,59.125 112.082,59.125 111.725,59.482 111.725,59.518 111.368,59.875 110.684,59.875 110.4,59.591 110.4,59.015 110.415,59
  Bottom Layer w0.25: U43.13@102.969,56.829 v1@104.349,56.829
AIN1_SCL_ISO: R168.1 R251.2 U39.16 U43.11 | length 15.4
  Top Layer w0.15: R251.2@99.8,59.063 103.948,59.063 104.255,59.37 v1(104.35,59.37)
  Bottom Layer w0.15: U43.11@102.969,59.369 v1@104.349,59.369 ; v1(104.35,59.37) 107.927,59.37 109.525,60.968 U39.16@109.525,62.25 109.6,62.325 109.6,63.039 110.241,63.68 110.241,63.975 110.266,64 R168.1@110.45,64
AIN1_SDA_ISO: R170.1 R252.2 U39.15 U43.14 | length 22.8
  Top Layer w0.15: R252.2@99.8,54.663 103.453,54.663 v1(104.35,55.56)
  Bottom Layer w0.15: U43.14@102.95,55.558 102.921,55.587 101.863,55.587 101.65,55.8 101.65,59.7 101.989,60.039 107.774,60.039 108.875,61.141 U39.15@108.875,62.25 108.875,63.296 109.355,63.776 109.355,64.005 R170.1@109.55,64.2
  Bottom Layer w0.25: U43.14@102.969,55.559 v1@104.349,55.559
AIN2+: D25.1 J5.20 RA7.2 U38.4 | length 21.2
  Bottom Layer w0.15: RA7.2@111.1,84.55 111.8,84.55 111.9,84.45 111.9,83.42 112.086,83.234 112.21,83.234 112.251,83.275 113.193,83.275 113.359,83.44 113.66,83.44 114.15,82.95 115.475,82.95 ; D25.1@113,88.038 113.12,88.038 114.162,88.038 115.475,86.725 115.475,82.95 ; U38.4@115.475,80.78 115.475,82.95
  Bottom Layer w0.25: D25.1@113.12,88.038 114.582,89.5 J5.20@118.9,89.5
AIN2-: D25.2 J5.19 PTC6.1 | length 17.7
  Top Layer w0.25: PTC6.1@112.116,84.2 112.116,86.816 113,87.7 v1(113,90.6)
  Bottom Layer w0.5: v1(113,90.6) D25.2@113,92.068 116.732,92.068 118,90.8 120.1,90.8 J5.19@121.4,89.5
AIN2_DRDY_3V3: R259.1 U45.7 U48.15 | length 49.7
  Top Layer w0.25: v1(94.831,83.929) 95.455,84.553 R259.1@96.6,84.553
  Bottom Layer w0.15: U48.15@66.8,60 66.8,59.55 66.809,59.541 66.809,59.365 67.024,59.15 68.05,59.15 70.4,61.5 70.4,62.55 69,63.95 69,64.974 69.476,65.45 79.276,65.45 86.15,72.324 86.15,77.974 87.36,79.184 89.934,79.184 90.7,79.95 90.7,82.228 92.358,83.886 93.408,83.886 U45.7@93.45,83.928 93.451,83.929 v1(94.831,83.929)
AIN2_DRDY_ISO: R173.1 R259.2 U40.14 U45.10 | length 13.6
  Top Layer w0.25: R259.2@99.8,84.553 103.727,84.553 v1(104.35,83.93)
  Bottom Layer w0.15: U40.14@108.225,85.6 108.284,85.659 108.284,86.534 108.65,86.9 R173.1@108.65,87.55
  Bottom Layer w0.25: U45.10@102.969,83.929 v1@104.349,83.929 ; v1(104.35,83.93) 107.78,83.93 108.225,84.375 U40.14@108.225,85.6
AIN2_MODE_3V3: R260.1 U45.4 U48.19 | length 54.5
  Top Layer w0.25: v1(94.831,80.119) 96.566,80.119 R260.1@96.6,80.153
  L2-Signal w0.15: v1(61.9,58.9) 61.9,59.8 63.1,61 63.1,63.5 64.9,65.3 80.55,65.3 81.7,66.45 v1(81.7,66.544)
  Bottom Layer w0.15: v1(61.9,58.9) 61.95,58.85 61.95,58.35 62.2,58.1 64.05,58.1 65.2,59.25 U48.19@65.2,59.95 ; v1(81.7,66.544) 81.7,67.45 86.45,72.2 86.45,77.85 87.484,78.884 91.566,78.884 92.8,80.118 U45.4@93.45,80.118
  Bottom Layer w0.25: U45.4@93.45,80.118 v1(94.831,80.119)
AIN2_MODE_ISO: Q10.2 Q10.5 R174.2 R260.2 U45.13 X63.1 | length 31.8
  Top Layer w0.15: R260.2@99.8,80.153 99.833,80.12 v1(104.35,80.12)
  Bottom Layer w0.15: v1(104.35,80.12) 104.35,81.097 104.603,81.35 107.8,81.35 108.503,82.053 110.078,82.053 ; Q10.2@110.725,82.053 110.078,82.053 ; X63.1@115.7,88.2 115.7,87.018 115.958,86.761 115.958,80.214 115.048,79.305 113.308,79.305 113,79.613 R174.2@113,82.053 Q10.5@112.075,82.053 111.792,82.053 111.597,82.248 111.597,82.356 111.175,82.778 111.175,82.796 111.043,82.928 110.345,82.928 110.078,82.661 110.078,82.053
  Bottom Layer w0.25: U45.13@102.969,80.119 v1@104.349,80.119
AIN2_SCL_ISO: R169.1 R257.2 U40.16 U45.11 | length 15.3
  Top Layer w0.25: R257.2@99.8,82.353 103.948,82.353 104.255,82.66 v1(104.35,82.66)
  Bottom Layer w0.15: U40.16@109.525,85.6 109.6,85.675 109.6,86.5 110.241,87.141 110.241,87.325 110.266,87.35 R169.1@110.45,87.35
  Bottom Layer w0.25: U45.11@102.969,82.659 v1@104.349,82.659 ; v1(104.35,82.66) 107.687,82.66 109.525,84.498 U40.16@109.525,85.6
AIN2_SDA_ISO: R171.1 R258.2 U40.15 U45.14 | length 23.1
  Top Layer w0.15: R258.2@99.8,77.953 103.453,77.953 v1(104.35,78.85)
  Bottom Layer w0.15: U45.14@102.95,78.848 101.802,78.848 101.35,79.3 101.35,82.7 101.95,83.3 107.7,83.3 108.875,84.475 U40.15@108.875,85.6 108.875,86.646 109.355,87.126 109.355,87.355 R171.1@109.55,87.55
  Bottom Layer w0.25: U45.14@102.969,78.849 v1@104.349,78.849
AIN_CTRL.AIN1_DRDY: M1.220 U48.6 | length 6.3
  Top Layer w0.15: v1(68.35,63) 68.4,63 69,63.6 M1.220@69,65.6
  Bottom Layer w0.15: U48.6@66,61.35 66.025,61.375 66.025,61.919 67.056,62.95 68.3,62.95 v1(68.35,63)
AIN_CTRL.AIN1_MODE: M1.216 U48.2 | length 7.9
  Top Layer w0.15: v1(66.4,63.65) 66.486,63.564 66.869,63.564 67.033,63.4 67.542,63.4 68,63.858 M1.216@68,65.6
  Bottom Layer w0.15: U48.2@64.4,61.5 64.4,62.133 64.225,62.308 64.225,63.225 64.831,63.831 66.097,63.831 66.278,63.65 v1(66.4,63.65)
AIN_CTRL.AIN2_DRDY: M1.222 U48.7 | length 6.6
  Top Layer w0.15: v1(69.15,62.85) 69.15,62.892 69.5,63.242 M1.222@69.5,65.6
  Bottom Layer w0.15: U48.7@66.4,61.35 66.425,61.375 66.425,61.895 67.005,62.475 68.775,62.475 v1(69.15,62.85)
AIN_CTRL.AIN2_MODE: M1.218 U48.3 | length 8
  Top Layer w0.15: v1(65.85,63.1) 67.667,63.1 68.5,63.933 M1.218@68.5,65.6
  Bottom Layer w0.15: U48.3@64.8,61.35 64.8,62.158 64.525,62.433 64.525,62.925 65,63.4 65.537,63.4 65.837,63.1 v1(65.85,63.1)
AVDD12: C39.2 C43.2 C46.2 C49.1 C51.2 C52.2 C54.1 C55.1 C56.2 C57.2 C59.1 C60.1 L7.2 U8.10 U8.16 U8.34 U8.46 U8.52 U8.53 | length 45.8
  Top Layer w0.25: C49.1@26.4,21.9 26.515,22.015 27.021,22.015 27.284,22.279 27.284,22.766 27.37,22.853 v1(27.37,22.947) ; C46.2@26.4,22.7 27.123,22.7 v1@27.237,22.814 ; v1(29.311,22.606) 29.311,22.701 29.575,22.964 29.575,23.225 C54.1@29.7,23.35 ; C56.2@30.9,29.65 30.911,29.639 v1(30.911,28.889) 30.978,28.956 31.256,28.956 31.575,29.275 31.575,29.525 C60.1@31.7,29.65 ; C57.2@32.85,29.65 32.962,29.538 32.962,29.238 v1(33.311,28.889) 33.649,29.226 33.649,29.549 C52.2@33.75,29.65 ; C59.1@35.173,21.15 35.168,21.155 34.645,21.155 34.45,21.35 v1(34.45,21.95) C55.1@35.173,21.95
  Top Layer w0.5: C51.2@29.311,21.85 v1(29.311,22.606)
  Top Layer w0.75: v1(27.5,34.95) L7.2@28.453,34.95
  L2-Signal w0.5: v1(27.37,22.947) 27.37,21.88 28.05,21.2 29.315,21.2 ; v1(27.5,34.95) 29.9,32.55 29.9,30.6 30.911,29.589 ; v1(29.311,22.606) 29.311,21.203 29.315,21.2 ; v1(30.911,28.889) 30.911,29.589 ; v1(33.311,28.889) 34.45,27.75 v1(34.45,21.95) 33.7,21.2 29.315,21.2 ; v1@33.358,28.869 32.627,29.6 30.923,29.6 30.911,29.589
  Bottom Layer w0.15: C43.2@25.4,22.547 U8.52@26.564,22.547 ; U8.53@26.564,22.947 v1(27.37,22.947) ; 27.176,22.547 27.287,22.658 ; U8.34@34.45,22.539 U8.34@34.459,22.547
  Bottom Layer w0.2: U8.52@26.564,22.547 27.176,22.547 ; U8.46@29.311,21.8 v1(29.311,22.606) ; v1(30.911,28.889) U8.10@30.911,29.695 ; v1(33.311,28.889) U8.16@33.311,29.695 ; v1(34.45,21.95) U8.34@34.45,22.539
  Bottom Layer w0.5: C39.2@26.65,35.166 27.257,35.166 27.473,34.95 v1(27.5,34.95)
AVDD33: C21.2 C26.2 C30.2 C33.2 C36.2 C40.2 C44.2 C47.2 C50.2 C53.2 L5.2 U8.4 U8.56 U8.61 U8.66 | length 16.7
  Top Layer w0.5: C21.2@20.231,27.181 21.081,27.181 v1(21.1,27.2) 21.103,27.197 21.98,27.197 L5.2@21.983,27.194
  L2-Signal w0.5: v1(21.1,27.2) 27.317,27.2 27.37,27.147 ; v1(27.37,24.147) v1(27.37,26.147) 27.37,27.147 ; v1(28.511,28.889) 28.492,28.869 28.119,28.869 27.397,28.147 v1(27.37,28.147) 27.37,27.147
  Bottom Layer w0.2: U8.56@26.564,24.147 v1(27.37,24.147) ; U8.61@26.564,26.147 v1(27.37,26.147) ; U8.66@26.564,28.147 v1(27.37,28.147) ; v1(28.511,28.889) U8.4@28.511,29.695
CAN1_H: J6.2 J19.2 U22.7 U24.2 | length 21.6
  Top Layer w0.15: 117.85,12.62 117.85,11.53 118.9,10.48 118.9,8.115 J19.2@120,7.015 118.4,5.415 118.4,4 118.715,3.685 119.381,3.685 119.741,4.045 U22.7@120.161,4.045
  Bottom Layer w0.15: U24.2@116.6,14.975 116.6,14.85 116.275,14.525 116.199,14.525 116.036,14.362 116.036,14.238 116.124,14.15 117.403,14.15 117.85,13.703 117.85,13.245 117.864,13.232 117.864,13.019 v1(117.95,12.933)
  Bottom Layer w0.25: U24.2@116.6,14.975 116.325,15.25 116.325,15.496 116.3,15.521 116.3,16.05 117.25,17 118.65,17 118.9,16.75 J6.2@118.9,15.5
CAN1_L: J6.4 J18.2 U22.6 U24.1 | length 22.7
  Top Layer w0.15: 117.3,12.637 117.3,11.302 118.35,10.252 118.35,7.965 J18.2@117.4,7.015 118.215,6.2 118.215,6.075 117.85,5.71 117.85,3.772 118.487,3.135 119.35,3.135 119.71,2.775 U22.6@120.161,2.775
  Bottom Layer w0.15: U24.1@115.199,14.85 115.3,14.85 115.625,14.525 115.625,14.424 115.7,14.349 115.7,13.898 115.923,13.675 117.1,13.675 117.3,13.475 117.3,13.263 117.286,13.249 117.286,13.036 v1(117.2,12.95)
  Bottom Layer w0.25: U24.1@115.3,15.1 115.7,15.5 115.7,16.1 117.15,17.55 118.65,17.55 118.9,17.8 J6.4@118.9,19
CAN1RX_1V8: M1.22 R227.2 R235.1 U20.3 | length 160.2
  Top Layer w0.15: M1.22@17.5,65.6 17.5,63.474 19.805,61.169 27.045,61.169 28.026,62.15 58.274,62.15 60.274,60.15 64.85,60.15 65.4,59.6 68.5,59.6 70.35,61.45 70.35,62.359 71.141,63.15 75.324,63.15 76.912,61.563 77.44,61.563 78.075,60.928 78.522,60.928 v1(78.6,60.85) ; v1(103.25,4.5) 103.31,4.56 104.25,4.56 105.281,5.591 105.281,6.191 105.615,6.525 U20.3@106.819,6.525
  Top Layer w0.25: v1(89.1,23.313) R227.2@89.1,24.05
  L1-Signal w0.15: v1(78.6,60.85) 78.661,60.911 78.661,61.375 80.688,63.403 86.474,63.403 89.102,60.775 89.102,56.825 94.631,51.297 94.631,47.653 93.878,46.9 93.878,38.55 95,37.427 95,36.473 94.353,35.826 94.353,29.703 89.1,24.45 v1(89.1,23.313)
  L2-Signal w0.15: v1(89.1,23.313) 89.115,23.298 89.115,22.885 90.809,21.191 90.809,18.141 103.25,5.7 v1(103.25,4.5)
  Bottom Layer w0.15: v1(103.25,4.5) 103.3,4.55 106.49,4.55 106.9,4.96 R235.1@108.6,4.96
CAN1TX_1V8: M1.20 R225.2 R234.1 U20.2 | length 157.8
  Top Layer w0.15: M1.20@17,65.6 17.005,65.595 17.005,64.588 17.025,64.567 17.025,63.525 19.681,60.869 27.169,60.869 28.15,61.85 58.15,61.85 60.2,59.8 64.776,59.8 65.326,59.25 68.6,59.25 70.65,61.3 70.65,62.235 71.265,62.85 75.2,62.85 76.787,61.263 76.987,61.263 v1(77.4,60.85) ; v1(102.95,7.71) 103.51,7.15 105.539,7.15 106.184,7.795 U20.2@106.819,7.795
  Top Layer w0.25: v1(90,23.313) R225.2@90,24.05
  L1-Signal w0.15: v1(77.4,60.85) 77.859,61.309 78.102,61.309 80.495,63.703 86.599,63.703 89.402,60.899 89.402,56.949 94.931,51.421 94.931,47.529 94.178,46.776 94.178,38.674 95.3,37.551 95.3,36.349 94.653,35.702 94.653,29.503 90,24.85 v1(90,23.313)
  L2-Signal w0.15: v1(90,23.313) 90,22.55 91.109,21.441 91.109,18.265 101.664,7.71 v1(102.95,7.71)
  Bottom Layer w0.15: v1(102.95,7.71) 103.51,7.15 108.59,7.15 R234.1@108.6,7.16
CAN2_H: J6.6 J21.2 U23.7 U25.1 | length 15.9
  Top Layer w0.15: U23.7@109.261,18.93 109.896,18.93 110.138,18.688 110.138,18.661 110.4,18.4 111.2,18.4 J21.2@111.7,18.9
  Bottom Layer w0.15: J21.2@111.7,18.9 112.802,18.9 113.577,18.125 114.6,18.125 115.975,19.5 115.975,21.247 116.175,21.447 116.175,21.7 116.55,22.075 U25.1@116.55,22.2
  Bottom Layer w0.25: U25.1@116.55,22.2 116.55,22.325 116.625,22.4 116.625,22.954 117.646,23.975 118.812,23.975 118.9,23.887 J6.6@118.9,22.5
CAN2_L: J6.8 J20.2 U23.6 U25.2 | length 16.3
  Top Layer w0.15: U23.6@109.261,17.66 109.896,17.66 110.336,18.1 112.35,18.1 113.15,18.9 J20.2@114.1,18.9
  Bottom Layer w0.15: J20.2@114.1,18.9 114.951,18.9 115.675,19.624 115.675,21.4 115.625,21.45 115.625,21.7 115.25,22.075 U25.2@115.25,22.2
  Bottom Layer w0.25: U25.2@115.25,22.2 115.25,22.325 115.639,22.714 115.639,23.104 115.785,23.25 116.214,23.25 116.575,23.611 117.489,24.525 118.812,24.525 118.9,24.613 J6.8@118.9,26
CAN2RX_1V8: M1.26 R228.2 R239.1 U21.3 | length 140.5
  Top Layer w0.15: M1.26@18.5,65.6 18.495,65.595 18.495,64.588 18.475,64.567 18.475,63.348 20.053,61.769 26.797,61.769 27.777,62.75 58.523,62.75 60.523,60.75 65.099,60.75 65.524,60.325 68.351,60.325 69.75,61.724 69.75,62.608 70.892,63.75 75.573,63.75 76.573,62.75 v1(78.05,62.75) ; U21.3@95.72,18.965 96.355,18.965 96.672,18.648 96.897,18.423 96.897,16.447 v1(96.45,16)
  Top Layer w0.25: v1(91.8,23.313) R228.2@91.8,24.05
  L1-Signal w0.15: v1(78.05,62.75) 79.603,64.303 86.847,64.303 90.002,61.148 90.002,57.359 96.475,50.886 96.475,47.875 94.778,46.178 94.778,39.047 94.778,38.922 95.9,37.8 95.9,36.1 95.253,35.453 95.253,27.103 91.852,23.702 91.852,23.365 v1(91.8,23.313)
  L2-Signal w0.15: v1(91.8,23.313) 91.814,23.298 91.814,22.884 92.073,22.625 92.267,22.625 92.575,22.317 92.575,21.852 92.225,21.502 92.225,18.909 92.959,18.175 93.167,18.175 95.342,16 v1(96.45,16)
  Bottom Layer w0.15: v1(96.45,16) 96.45,16.05 97.5,17.1 R239.1@97.5,17.4
CAN2TX_1V8: M1.24 R226.2 R238.1 U21.2 | length 137.1
  Top Layer w0.15: M1.24@18,65.6 18,63.399 19.929,61.469 26.921,61.469 27.901,62.45 58.399,62.45 60.399,60.45 64.974,60.45 65.399,60.025 68.475,60.025 70.05,61.6 70.05,62.483 71.017,63.45 75.449,63.45 76.999,61.9 v1(77.95,61.9) ; v1(92.05,22.1) 92.05,21.55 92.621,20.979 93.314,20.979 94.058,20.235 U21.2@95.72,20.235
  Top Layer w0.25: v1(90.9,23.313) R226.2@90.9,24.05
  L1-Signal w0.15: v1(77.95,61.9) 80.053,64.003 86.723,64.003 89.702,61.023 89.702,57.234 96.175,50.762 96.175,48.349 94.478,46.652 94.478,38.798 95.6,37.676 95.6,36.224 94.953,35.578 94.953,27.366 v1(90.9,23.313)
  L2-Signal w0.15: v1(90.9,23.313) 90.9,23.25 v1(92.05,22.1)
  Bottom Layer w0.15: v1(92.05,22.1) 95.954,22.1 96.232,21.823 97.477,21.823 R238.1@97.5,21.8
CLK_OUT: U26.18 X51.1 | length 5.8
  Bottom Layer w0.15: X51.1@44.15,29.15 44.075,29.075 44.075,23.975 44.225,23.825 U26.18@44.6,23.825
CTRL_RECOVERY_MICO#: M1.246 R218.1 | length 99.9
  Top Layer w0.15: M1.246@75.5,65.6 75.5,64.524 75.637,64.387 76.97,64.387 77.332,64.025 v1(77.35,64.025)
  L1-Signal w0.15: v1(43.85,36.55) 48.3,36.55 50.65,38.9 51.6,38.9 54.9,42.2 56.4,42.2 57.1,42.9 v1(57.1,42.95)
  L3-Signal w0.15: v1(16.35,16.35) 16.392,16.308 17.008,16.308 20.9,20.2 20.9,23.518 24.925,27.543 24.925,30.333 25.625,31.033 25.625,31.042 26.808,32.225 30.375,32.225 30.95,32.8 34.076,32.8 37.769,36.493 43.793,36.493 v1(43.85,36.55) ; v1(57.1,42.95) 57.65,42.95 59.3,44.6 59.3,48.2 59.55,48.45 62.55,48.45 64.35,50.25 66.2,50.25 67.25,51.3 67.25,58.696 67.279,58.725 ; 67.25,58.726 71.774,63.25 76.642,63.25 77.35,63.958 v1(77.35,64.025)
  Bottom Layer w0.15: R218.1@15.55,11.525 15.55,13.209 15.113,13.646 15.113,14.855 15.42,15.163 16.005,15.163 16.35,15.508 v1(16.35,16.35)
CTRL_RESET_MICO#: M1.260 R219.1 | length 106.2
  Top Layer w0.15: M1.260@79,65.6 79,64.5 79.35,64.15 80.642,64.15 82.15,62.642 82.15,60.641 v1(82.106,60.598)
  L1-Signal w0.15: v1(43.65,35.8) 44.45,35 48.45,35 49.75,36.3 49.75,37.5 50.85,38.6 51.75,38.6 55.05,41.9 56.976,41.9 59.85,44.774 v1(59.85,45.45)
  L3-Signal w0.15: v1(15.8,15.7) 17,15.7 21.2,19.9 21.2,23.394 25.225,27.419 25.225,30.208 25.925,30.908 25.925,30.917 26.858,31.85 30.658,31.85 31.108,32.3 34,32.3 37.85,36.15 43.3,36.15 v1(43.65,35.8) ; v1(59.85,45.45) 59.85,47.9 59.925,47.975 67.275,47.975 72.1,52.8 72.1,55.753 73.844,57.497 79.006,57.497 v1(82.106,60.598)
  Bottom Layer w0.15: R219.1@14.05,11.525 14.05,14.688 15.062,15.7 v1(15.8,15.7)
CTRL_RESET_MOCI#: M1.258 R8.1 R121.1 U26.43 | length 71.2
  Top Layer w0.15: M1.258@78.5,65.6 78.5,64.45 79.1,63.85 80.15,63.85 81.4,62.6 v1(81.4,60.85)
  L1-Signal w0.15: v1(55.25,25.2) 56.441,26.391 57.999,26.391 58.796,27.187 58.796,29.021 64.975,35.201 64.975,37.551 71.05,43.626 71.05,51.65 72.2,52.8 72.2,60.726 76.074,64.6 77.672,64.6 78,64.272 78,63.7 76.85,62.55 76.85,60.658 77.208,60.3 80.85,60.3 v1(81.4,60.85)
  Bottom Layer w0.15: U26.43@51.4,23.825 51.417,23.808 51.9,23.808 51.933,23.775 52.367,23.775 52.417,23.825 52.854,23.825 R121.1@52.875,23.803 54.147,23.803 R8.1@54.15,23.8 54.15,23.85 55.164,24.864 55.164,25.114 v1(55.25,25.2)
CTRL_WAKE1_MICO#: M1.252 R132.1 | length 10.7
  Top Layer w0.15: M1.252@77,65.6 77,66.7 77.6,67.3 80.026,67.3 81.8,69.074 81.8,70.9 82.6,71.7 R132.1@83.45,71.7
DIGI_1: M1.56 R197.2 U62.3 | length 89.7
  Top Layer w0.15: M1.56@26,65.6 26,67.05 27.65,68.7 27.65,74.05 34.3,80.7 v1(35.35,80.7) ; v1(91.6,97.5) 91.902,97.198 U62.3@92.795,97.198 94.15,97.198 R197.2@94.175,97.173
  L1-Signal w0.15: v1(35.35,80.7) 36.25,81.6 48.079,81.6 48.479,82 51.701,82 54.138,84.436 54.138,90.53 55.774,92.166 73.992,92.166 80.026,98.2 90.9,98.2 v1(91.6,97.5)
DIGI_2: M1.58 R198.2 U63.3 | length 84.5
  Top Layer w0.15: M1.58@26.5,65.6 26.5,66.974 28.1,68.574 28.1,73.935 34.34,80.175 35.623,80.175 v1(36.102,80.653) ; U63.3@85.865,97.15 87.292,97.15 R198.2@87.295,97.153 88.097,97.153 v1(88.1,97.15)
  L1-Signal w0.15: v1(36.102,80.653) 36.102,80.775 36.627,81.3 48.203,81.3 48.603,81.7 51.826,81.7 54.438,84.312 54.438,90.405 55.898,91.866 74.116,91.866 79.4,97.15 v1(88.1,97.15)
DIO1+: D27.2 D29.1 J5.12 | length 79.3
  Top Layer w0.15: D29.1@93.255,81.948 D29.1@93.275,81.969
  Top Layer w0.25: v1(93.45,86.1) 93.438,86.088 93.438,84.846 D27.2@93.525,84.758 D29.1@93.525,81.969
  L1-Signal w0.25: v1(93.45,86.1) 93.45,88.499 91.146,90.803 91.146,94.472 94.223,97.55 97.082,97.55 100.232,100.7 121.735,100.7 128.1,94.335 128.1,91.65 124.25,87.8 124.25,79.5 122.05,77.3 120.4,77.3 118.9,75.8 J5.12@118.9,75.5
DIO1-: D27.1 J5.11 U60.3 U62.2 | length 78.3
  Top Layer w0.25: U60.3@89.605,87.198 89.605,86.533 89.805,86.333 92.005,86.333 93.275,87.604 D27.1@93.275,88.788 ; v1(91.4,96) 92.795,94.605 92.795,90.348 93.255,89.888 D27.1@93.255,88.863
  L1-Signal w0.25: v1(91.4,96) 93.5,98.1 96.854,98.1 100.004,101.25 121.963,101.25 128.65,94.563 128.65,91.4 124.8,87.55 124.8,78.9 J5.11@121.4,75.5
DIO2+: D28.2 D30.1 J5.14 | length 76.3
  Top Layer w0.25: D30.1@86.575,81.925 D28.2@86.575,84.708 86.695,84.708 88.099,86.112 88.099,90.349 89.121,91.371 89.121,92.771 89.9,93.55 v1(91.9,93.55)
  L1-Signal w0.25: v1(91.9,93.55) 91.958,93.55 93.008,92.5 95.7,92.5 96.9,93.7 96.9,95.484 101.066,99.65 121.3,99.65 127.05,93.9 127.05,92.1 123.2,88.25 123.2,81.55 122.3,80.65 120.55,80.65 J5.14@118.9,79
DIO2-: D28.1 J5.13 U61.3 U63.2 | length 76.9
  Top Layer w0.25: U61.3@82.675,87.15 82.675,86.485 82.875,86.285 85.075,86.285 86.575,87.785 D28.1@86.575,88.738 86.575,89.59 85.865,90.3 U63.2@85.865,90.7 87.6,90.7 88.63,91.73 88.63,93.13 89.9,94.4 v1(91.9,94.4)
  L1-Signal w0.25: v1(91.9,94.4) 92.683,94.4 93.883,93.2 95.25,93.2 96.147,94.097 96.147,95.547 100.75,100.15 121.507,100.15 127.55,94.107 127.55,91.85 123.7,88 123.7,81.3 J5.13@121.4,79
DS2_N: C254.1 J16.U8 | length 7.3
  Top Layer w0.2: J16.U8@28.25,14.769 27.7,15.319 27.7,15.789 27.7,15.955 28.495,16.75 30.03,16.75 30.041,16.738 31.883,16.738 32.12,16.501 v1(32.2,16.501)
  Bottom Layer w0.2: C254.1@31.5,17 31.55,17 31.972,16.578 32.123,16.578 v1(32.2,16.501)
DS2_P: C259.1 J16.U9 | length 8.5
  Top Layer w0.2: J16.U9@26.25,14.769 26.422,14.941 26.958,14.941 27.35,15.333 27.35,15.644 27.35,16.1 28.35,17.1 30.175,17.1 30.186,17.088 31.982,17.088 32.143,17.249 v1(32.251,17.249)
  Bottom Layer w0.2: C259.1@31.5,17.8 31.55,17.8 31.85,17.5 31.904,17.5 32.154,17.249 v1(32.251,17.249)
DS2_RX_N: J16.U5 U8.44 U70.4 U70.7 | length 13.2
  Bottom Layer w0.2: U8.44@30.111,21.8 30.109,21.798 30.109,21.224 29.592,20.707 28.935,20.707 28.625,20.396 28.625,20.117 28.675,20.067 28.675,19.742 U70.7@28.7,19.717 28.7,19.529 28.675,19.504 28.634,19.504 28.625,19.496 28.625,19.146 28.7,19.071 U70.4@28.7,18.883 28.7,18.695 28.625,18.62 28.625,18.13 28.15,17.655 28.15,17.407 28.267,17.29 28.91,17.29 30,16.2 31.35,16.2 31.599,15.951 33.058,15.951 33.4,15.609 33.4,15.25 33.69,14.96 33.788,14.96 33.881,14.867 33.881,14.769 J16.U5@34.25,14.769
DS2_RX_P: J16.U6 U8.45 U70.5 U70.6 | length 13
  Bottom Layer w0.2: U8.45@29.711,21.8 29.709,21.798 29.709,21.319 29.447,21.057 28.79,21.057 28.275,20.541 28.275,20.117 28.225,20.067 28.225,19.742 U70.6@28.2,19.717 28.2,19.529 28.225,19.504 28.266,19.504 28.275,19.496 28.275,19.146 28.2,19.071 U70.5@28.2,18.883 28.2,18.695 28.275,18.62 28.275,18.275 27.8,17.8 27.8,17.262 28.122,16.94 28.765,16.94 29.855,15.85 31.205,15.85 31.454,15.601 32.913,15.601 33.05,15.464 33.05,15.298 32.521,14.769 J16.U6@32.25,14.769
DS2_TX_N: C254.2 U8.42 U70.2 U70.9 | length 6
  Bottom Layer w0.2: C254.2@30.5,17 30.4,17.1 30.35,17.1 30.15,17.3 30.096,17.3 29.775,17.621 29.775,18.621 29.7,18.695 U70.2@29.7,18.883 29.7,19.071 29.775,19.145 29.775,19.496 29.766,19.504 29.725,19.504 29.7,19.529 U70.9@29.7,19.717 29.7,19.904 29.825,20.029 29.825,20.174 30.301,20.65 30.7,20.65 30.948,20.898 30.948,21.396 30.913,21.431 30.913,21.798 U8.42@30.911,21.8
DS2_TX_P: C259.2 U8.41 U70.1 U70.10 | length 5
  Bottom Layer w0.2: C259.2@30.5,17.8 30.35,17.95 30.242,17.95 30.125,18.067 30.125,18.483 30.175,18.533 30.175,18.858 U70.1@30.2,18.883 30.2,19.071 30.125,19.146 30.125,19.454 30.2,19.529 U70.10@30.2,19.717 30.225,19.742 30.225,20.08 30.445,20.3 30.845,20.3 31.298,20.753 31.298,21.408 31.309,21.419 31.309,21.798 U8.41@31.311,21.8
DS3_N: C256.1 J16.L8 | length 23.5
  Top Layer w0.2: J16.L8@28.25,11.569 27.681,11 27.681,10.835 28.1,10.416 28.1,9.545 29.195,8.45 30.665,8.45 31.95,8.45 ccw(c31.95,8.715) 32.215,8.715 32.215,9.102 cw(c32.481,9.102) 32.746,9.102 32.746,8.715 ccw(c33.011,8.715) 33.011,8.45 33.641,8.45 33.805,8.45 36.305,10.95 37.472,10.95 38.75,12.228 38.75,15.125 37.3,16.575 36.608,16.575 36.408,16.375 v1(36.3,16.375)
  Bottom Layer w0.2: C256.1@35.45,16.35 35.5,16.35 35.725,16.575 36.005,16.575 36.074,16.506 36.169,16.506 v1(36.3,16.375)
DS3_P: C260.1 J16.L9 | length 24.3
  Top Layer w0.2: J16.L9@26.25,11.569 26.452,11.569 27.75,10.271 27.75,9.4 29.05,8.1 33.95,8.1 36.45,10.6 37.617,10.6 39.1,12.083 39.1,15.27 37.445,16.925 36.608,16.925 36.408,17.125 v1(36.3,17.125) v1@36.272,17.125
  Bottom Layer w0.2: C260.1@35.45,17.15 35.5,17.15 35.725,16.925 36.1,16.925 v1(36.3,17.125)
DS3_RX_N: J16.L5 U8.36 U69.4 U69.7 | length 30.1
  Bottom Layer w0.2: U8.36@33.311,21.8 33.311,21.498 33.336,21.473 33.336,20.919 33.925,20.33 33.925,19.98 33.85,19.904 U69.4@33.85,19.717 33.85,19.529 33.875,19.504 33.916,19.504 33.925,19.496 33.925,19.104 33.916,19.096 33.875,19.096 33.85,19.071 33.85,18.695 33.975,18.57 33.975,18.504 34.032,18.447 34.032,18.072 34.354,17.75 37,17.75 38.75,16 38.75,15.448 38.75,15.173 ccw(c39.365,15.173) 39.365,14.558 41.432,14.558 cw(c41.432,14.293) 41.697,14.293 cw(c41.432,14.293) 41.432,14.028 39.365,14.028 ccw(c39.365,13.413) 38.75,13.413 38.75,12.446 38.75,12.4 38.1,11.75 37.405,11.75 37.391,11.736 36.892,11.237 cw(c36.677,11.451) 36.463,11.237 36.342,11.358 ccw(c36.127,11.144) 35.913,11.358 ccw(c36.127,11.144) 35.913,10.93 36.034,10.808 cw(c35.82,10.594) 36.034,10.379 35.563,9.908 34.755,9.1 33.195,9.1 32.7,9.595 32.7,10.221 33.425,10.946 33.425,11.257 33.546,11.378 34.059,11.378 J16.L5@34.25,11.569
DS3_RX_P: J16.L6 U8.35 U69.5 U69.6 | length 30.2
  Bottom Layer w0.2: J16.L6@32.25,11.569 32.441,11.378 32.954,11.378 33.075,11.257 33.075,11.091 32.35,10.366 32.35,9.45 33.05,8.75 34.9,8.75 37.55,11.4 38.245,11.4 39.1,12.255 39.1,12.446 39.1,13.413 cw(c39.365,13.413) 39.365,13.678 41.432,13.678 ccw(c41.432,14.293) 42.047,14.293 ccw(c41.432,14.293) 41.432,14.908 39.365,14.908 cw(c39.365,15.173) 39.1,15.173 39.1,15.448 39.1,16.145 37.145,18.1 34.499,18.1 34.382,18.217 34.382,18.592 34.375,18.599 34.375,18.858 U69.6@34.35,18.883 34.35,19.071 34.325,19.096 34.284,19.096 34.275,19.104 34.275,19.496 34.284,19.504 34.325,19.504 34.35,19.529 U69.5@34.35,19.717 34.35,19.904 34.275,19.98 34.275,20.475 33.686,21.064 33.686,21.473 33.711,21.498 U8.35@33.711,21.8
DS3_TX_N: C256.2 U8.39 U69.1 U69.10 | length 6.9
  Bottom Layer w0.2: U8.39@32.111,21.8 32.111,21.498 32.136,21.473 32.136,20.714 32.25,20.6 32.425,20.425 32.425,19.979 32.35,19.904 U69.1@32.35,19.717 32.35,19.529 32.375,19.504 32.416,19.504 32.425,19.496 32.425,19.145 32.35,19.071 U69.10@32.35,18.883 32.35,18.695 32.425,18.621 32.425,18.006 32.619,17.811 33.086,17.344 33.086,17.194 33.705,16.575 34.175,16.575 34.4,16.35 C256.2@34.45,16.35
DS3_TX_P: C260.2 U8.38 U69.2 U69.9 | length 6.3
  Bottom Layer w0.2: U8.38@32.511,21.8 32.511,21.498 32.486,21.473 32.486,20.859 32.775,20.57 32.775,19.98 32.85,19.904 U69.2@32.85,19.717 32.85,19.529 32.775,19.454 32.775,19.146 32.85,19.071 U69.9@32.85,18.883 32.825,18.858 32.825,18.533 32.775,18.483 32.775,18.151 32.969,17.956 33.436,17.489 33.436,17.339 33.85,16.925 34.175,16.925 34.4,17.15 C260.2@34.45,17.15
DSI_1_CLK_CON_N: J15.9 L38.3 | length 18.6
  Top Layer w0.2: J15.9@6.881,79.478 6.931,79.428 8.111,79.428 8.211,79.428 ccw(c8.211,79.703) 8.486,79.703 8.486,79.866 cw(c8.761,79.866) 8.761,80.141 cw(c8.761,79.866) 9.036,79.866 9.036,79.703 ccw(c9.311,79.703) 9.311,79.428 ccw(c9.311,79.703) 9.586,79.703 9.586,79.866 cw(c9.861,79.866) 9.861,80.141 cw(c9.861,79.866) 10.136,79.866 10.136,79.703 ccw(c10.411,79.703) 10.411,79.428 10.931,79.428 15.972,79.428 18.975,76.425 18.975,73.345 19,73.32 19,73.175 L38.3@19.05,73.125
DSI_1_CLK_CON_P: J15.8 L38.4 | length 18.9
  Top Layer w0.2: J15.8@4.081,78.978 7.685,78.978 7.785,79.078 15.827,79.078 18.625,76.28 18.625,73.317 18.6,73.292 18.6,73.175 L38.4@18.55,73.125
DSI_1_CLK_N: L38.2 M1.35 | length 27.2
  Top Layer w0.2: v1(18.98,70.63) 19.056,70.706 19.056,70.989 19.365,71.298 19.365,71.753 19,72.118 19,72.425 L38.2@19.05,72.475 ; v1(20.6,59.55) 20.6,59.442 20.8,59.242 20.8,58.729 20.825,58.704 20.825,58.424 20.8,58.399 20.8,57.45 M1.35@20.75,57.4
  L1-Signal w0.15: v1(18.98,70.63) 19.066,70.716 19.066,71.211 19.35,71.495 19.35,71.859 20.141,72.65 23.134,72.65 24.25,71.534 24.25,67.55 23.7,67 21.534,67 20.775,66.241 20.775,63.419 20.775,62.694 cw(c20.45,62.694) 20.45,62.369 20.365,62.369 ccw(c20.365,62.044) 20.04,62.044 ccw(c20.365,62.044) 20.365,61.719 20.45,61.719 cw(c20.45,61.394) 20.775,61.394 20.775,60.444 20.775,59.847 20.6,59.672 v1(20.6,59.55)
DSI_1_CLK_P: L38.1 M1.37 | length 26.9
  Top Layer w0.2: v1(18.449,71.16) 18.526,71.236 18.809,71.236 19.015,71.443 19.015,71.608 18.65,71.973 18.65,72.126 18.6,72.176 18.6,72.425 L38.1@18.55,72.475 ; M1.37@21.25,57.4 21.2,57.45 21.2,58.399 21.175,58.424 21.175,58.849 21.15,58.874 21.15,59.242 21.35,59.442 v1(21.35,59.55)
  L1-Signal w0.15: v1(18.449,71.16) 18.95,71.661 18.95,72.025 19.975,73.05 23.3,73.05 24.65,71.7 24.65,67.384 23.866,66.6 21.7,66.6 21.175,66.075 21.175,59.847 21.35,59.672 v1(21.35,59.55)
DSI_1_D0_CON_N: J15.3 L37.3 | length 12.1
  Top Layer w0.2: J15.3@6.881,76.478 6.981,76.378 9.378,76.378 10.35,77.35 13.2,77.35 15.675,74.875 15.675,73.32 15.7,73.295 15.7,73.15 L37.3@15.75,73.1
DSI_1_D0_CON_P: J15.2 L37.4 | length 14.3
  Top Layer w0.2: J15.2@4.081,75.978 4.131,76.028 7.733,76.028 9.523,76.028 10.153,76.658 10.495,77 13.055,77 13.939,76.116 15.325,74.73 15.325,74.218 15.325,73.32 15.3,73.295 15.3,73.15 L37.4@15.25,73.1
DSI_1_D0_N: L37.2 M1.47 | length 33
  Top Layer w0.2: v1(15.7,71.1) 15.725,71.125 15.725,72.425 L37.2@15.75,72.45 ; v1(23.6,59.6) 23.6,59.492 23.8,59.292 23.8,58.757 23.825,58.732 23.825,58.424 23.8,58.399 23.8,57.45 M1.47@23.75,57.4
  L1-Signal w0.15: v1(15.7,71.1) 15.779,71.179 15.779,71.463 18.766,74.45 24.034,74.45 26.55,71.934 26.55,71.217 26.55,70.642 cw(c26.3,70.642) 26.3,70.392 26.2,70.392 ccw(c26.2,70.142) 26.2,69.892 26.3,69.892 cw(c26.3,69.642) 26.3,69.392 26.2,69.392 ccw(c26.2,69.142) 26.2,68.892 26.3,68.892 cw(c26.3,68.642) 26.3,68.392 26.2,68.392 ccw(c26.2,68.142) 26.2,67.892 26.3,67.892 cw(c26.3,67.642) 26.55,67.642 26.55,66.426 26.55,65.25 23.8,62.5 23.8,59.922 23.6,59.722 v1(23.6,59.6)
DSI_1_D0_P: L37.1 M1.49 | length 31.1
  Top Layer w0.2: v1(15.17,71.63) 15.21,71.67 15.21,72.41 L37.1@15.25,72.45 ; M1.49@24.25,57.4 24.2,57.45 24.2,58.399 24.175,58.424 24.175,58.876 24.15,58.901 24.15,59.292 24.35,59.492 v1(24.35,59.6)
  L1-Signal w0.15: v1(15.17,71.63) 15.256,71.716 15.466,71.716 18.6,74.85 24.2,74.85 26.95,72.1 26.95,65.084 24.2,62.334 24.2,59.872 24.35,59.722 v1(24.35,59.6)
DSI_1_D1_CON_N: J15.6 L35.3 | length 17.5
  Top Layer w0.2: J15.6@4.081,77.978 7.685,77.978 7.785,77.878 9.178,77.878 9.7,78.4 15.15,78.4 17.325,76.225 17.325,73.345 17.35,73.32 17.35,73.175 L35.3@17.4,73.125
DSI_1_D1_CON_P: J15.5 L35.4 | length 17.5
  Top Layer w0.2: J15.5@6.881,77.478 9.273,77.478 9.845,78.05 14.472,78.05 15.005,78.05 15.181,77.874 cw(c14.933,77.627) 15.181,77.379 14.747,76.946 ccw(c14.994,76.698) 14.747,76.451 ccw(c14.994,76.698) 15.242,76.451 15.676,76.884 cw(c15.923,76.637) 16.171,76.884 cw(c15.923,76.637) 16.171,76.389 15.758,75.977 ccw(c16.006,75.73) 15.758,75.482 ccw(c16.006,75.73) 16.253,75.482 16.378,75.606 cw(c16.625,75.359) 16.975,75.359 16.975,74.937 16.975,73.317 16.95,73.292 16.95,73.175 L35.4@16.9,73.125
DSI_1_D1_N: L35.2 M1.41 | length 28.3
  Top Layer w0.2: v1(17.13,70.92) 17.13,71.024 17.502,71.396 17.502,71.974 17.35,72.126 17.35,72.425 L35.2@17.4,72.475 ; v1(22.1,60.25) 22.1,60.142 22.3,59.942 22.3,59.23 22.325,59.205 22.325,58.424 22.3,58.399 22.3,57.45 M1.41@22.25,57.4
  L1-Signal w0.15: v1@17.386,70.986 17.386,71.357 19.579,73.55 23.584,73.55 25.25,71.884 25.25,66.95 22.8,64.5 22.8,63.649 22.275,63.124 22.275,63.066 22.275,62.491 cw(c22.025,62.491) 22.025,62.241 21.906,62.241 ccw(c21.906,61.991) 21.906,61.741 22.025,61.741 cw(c22.025,61.491) 22.275,61.491 22.275,60.742 22.275,60.547 22.1,60.372 v1(22.1,60.25)
DSI_1_D1_P: L35.1 M1.43 | length 28.5
  Top Layer w0.2: v1(16.6,71.45) 16.677,71.527 17.016,71.527 17.152,71.663 17.152,71.829 17,71.981 17,72.126 16.95,72.176 16.95,72.425 L35.1@16.9,72.475 ; M1.43@22.75,57.4 22.7,57.45 22.7,58.399 22.675,58.424 22.675,59.35 22.65,59.375 22.65,59.942 22.85,60.142 v1(22.85,60.25)
  L1-Signal w0.15: v1(16.6,71.45) 16.665,71.515 16.978,71.515 19.413,73.95 23.75,73.95 25.65,72.05 25.65,66.784 23.2,64.334 23.2,63.483 22.675,62.958 22.675,60.547 22.85,60.372 v1(22.85,60.25)
DSI_1_D2_CON_N: J15.12 L36.3 | length 21.8
  Top Layer w0.2: J15.12@4.081,80.978 4.131,80.928 16.217,80.928 20.625,76.52 20.625,73.449 20.65,73.424 20.65,73.175 L36.3@20.7,73.125
DSI_1_D2_CON_P: J15.11 L36.4 | length 21.1
  Top Layer w0.2: J15.11@6.881,80.478 6.981,80.578 7.649,80.578 10.348,80.578 11.148,80.578 cw(c11.148,80.228) 11.498,80.228 11.498,80.194 ccw(c11.848,80.194) 12.198,80.194 12.198,80.228 cw(c12.548,80.228) 12.898,80.228 12.898,80.194 ccw(c13.248,80.194) 13.598,80.194 13.598,80.228 cw(c13.948,80.228) 14.298,80.228 14.298,80.194 ccw(c14.648,80.194) 14.998,80.194 14.998,80.228 cw(c15.348,80.228) 15.348,80.578 15.927,80.578 16.072,80.578 20.275,76.375 20.275,73.449 20.25,73.424 20.25,73.175 L36.4@20.2,73.125
DSI_1_D2_N: L36.2 M1.29 | length 23.8
  Top Layer w0.2: v1(19.1,60.25) 19.1,60.142 19.3,59.942 19.3,59.23 19.325,59.205 19.325,58.424 19.3,58.399 19.3,57.45 M1.29@19.25,57.4 ; v1(20.6,70.95) 20.668,71.018 20.668,72.108 20.65,72.126 20.65,72.425 L36.2@20.7,72.475
  L1-Signal w0.15: v1(19.1,60.25) 19.1,60.372 19.275,60.547 19.275,63.491 19.8,64.016 19.8,66.467 19.8,66.546 19.955,66.701 ccw(c19.749,66.906) 19.955,67.112 19.309,67.758 cw(c19.798,68.246) 19.309,68.735 cw(c19.798,68.246) 20.286,68.735 20.875,68.146 20.932,68.089 ccw(c21.138,68.295) 21.343,68.089 22.054,68.8 22.074,68.8 22.684,68.8 23.25,69.366 23.25,71.134 22.634,71.75 21.229,71.75 20.836,71.357 20.836,71.307 20.6,71.072 v1(20.6,70.95)
DSI_1_D2_P: L36.1 M1.31 | length 24.4
  Top Layer w0.2: M1.31@19.75,57.4 19.7,57.45 19.7,58.399 19.675,58.424 19.675,59.35 19.65,59.375 19.65,59.942 19.85,60.142 v1(19.85,60.25) ; v1(20.07,71.48) 20.07,71.55 20.318,71.797 20.318,71.963 20.3,71.981 20.3,72.126 20.25,72.176 20.25,72.425 L36.1@20.2,72.475
  L1-Signal w0.15: v1(19.85,60.25) 19.85,60.372 19.675,60.547 19.675,63.325 20.2,63.85 20.2,66.067 20.2,66.38 20.238,66.418 ccw(c19.749,66.906) 20.238,67.395 19.592,68.041 cw(c19.798,68.246) 19.592,68.452 cw(c19.798,68.246) 20.003,68.452 20.648,67.807 ccw(c21.138,68.295) 21.626,67.806 22.22,68.4 22.474,68.4 22.85,68.4 23.65,69.2 23.65,71.3 22.8,72.15 20.739,72.15 v1(20.07,71.48)
DSI_1_D3_CON_N: J15.15 L39.3 | length 24.4
  Top Layer w0.2: J15.15@6.881,82.478 6.956,82.403 17.092,82.403 18.804,80.691 18.875,80.62 ccw(c19.122,80.868) 19.37,80.62 20.053,81.304 cw(c20.301,81.056) 20.548,81.304 cw(c20.301,81.056) 20.548,80.809 19.865,80.125 ccw(c20.112,79.878) 19.865,79.63 20.4,79.095 20.47,79.025 22.275,77.22 22.275,73.449 22.3,73.424 22.3,73.175 L39.3@22.35,73.125
DSI_1_D3_CON_P: J15.14 L39.4 | length 23.9
  Top Layer w0.2: J15.14@4.081,81.978 7.772,81.978 7.847,82.053 16.947,82.053 21.925,77.075 21.925,73.449 21.9,73.424 21.9,73.175 L39.4@21.85,73.125