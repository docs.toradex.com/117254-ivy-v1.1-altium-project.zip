# Altium PCB 46806005.~(3).PcbDoc (part 9 of 9)
Units mm, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 130 x 105 mm, 8 copper layers (Top Layer, P1-GND, L1-Signal, L2-Signal, L3-Signal, L4-Signal, P2-GND, Bottom Layer), stack 1.63 mm thick; 795 components, 496 nets, 2816 pads, 1210 vias.
Unrouted connection lines stored in the file: 1.

## Silkscreen, mask and mechanical layers (free items; w line width, h text height) (continued)
95R - TOP:
  lines w0.18: 70.25,57.4 70.31,57.46 70.31,58.367 70.335,58.392 70.335,60.035 72.55,62.25 74.967,62.25 75.63,61.587 75.63,60.86 75.64,60.85 75.64,60.165 75.85,59.955 75.85,59.85 ; 70.6,53.4 70.6,53.505 70.81,53.715 70.81,54.107 71.109,54.405 73.589,54.405 75.335,56.152 75.335,56.408 75.31,56.433 75.31,57.34 75.25,57.4 ; 70.75,57.4 70.69,57.46 70.69,58.367 70.665,58.392 70.665,59.898 72.687,61.92 74.83,61.92 75.3,61.45 75.3,60.723 75.31,60.713 75.31,60.165 75.1,59.955 75.1,59.85 ; 71.25,55.05 71.355,55.05 71.565,55.26 73.525,55.26 74.165,55.9 74.165,56.408 74.19,56.433 74.19,57.34 74.25,57.4 ; 71.25,55.8 71.355,55.8 71.565,55.59 73.388,55.59 73.835,56.037 73.835,56.408 73.81,56.433 73.81,57.34 73.75,57.4 ; 71.35,53.4 71.35,53.505 71.14,53.715 71.14,53.97 71.245,54.075 73.725,54.075 75.665,56.015 75.665,56.408 75.69,56.433 75.69,57.34 75.75,57.4 ; 71.75,57.4 71.81,57.46 71.81,58.367 71.835,58.392 71.835,60.052 72.413,60.63 73.53,60.63 73.739,60.839 73.714,60.863 73.714,61.013 73.634,61.093 ; 72.25,57.4 72.19,57.46 72.19,58.367 72.165,58.392 72.165,59.915 72.55,60.3 73.667,60.3 74.384,61.017 74.384,61.093
95R - BOT:
  drawing of 408 lines, arcs and shapes, not listed