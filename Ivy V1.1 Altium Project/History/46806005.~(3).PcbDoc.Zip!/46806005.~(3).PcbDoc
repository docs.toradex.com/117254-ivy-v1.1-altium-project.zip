# Altium PCB 46806005.~(3).PcbDoc (part 7 of 9)
Units mm, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 130 x 105 mm, 8 copper layers (Top Layer, P1-GND, L1-Signal, L2-Signal, L3-Signal, L4-Signal, P2-GND, Bottom Layer), stack 1.63 mm thick; 795 components, 496 nets, 2816 pads, 1210 vias.
Unrouted connection lines stored in the file: 1.

## Via types
v1: diameter 0.6, hole 0.3, Top Layer to Bottom Layer, tented both sides, 1145 vias
v2: diameter 0.6, hole 0.3, Top Layer to Bottom Layer, 65 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
NetR134_2: R134.2 U31.7 U31.8 | length 5.4
  Top Layer w0.15: U31.8@52.58,100.575 54.075,100.575 ; U31.7@52.58,101.225 53.762,101.225 54.075,100.912 54.075,100.575 ; R134.2@55,99 55,99.65 54.075,100.575
NetR149_1: R149.1 R150.2 U32.7 | length 2.8
  Top Layer w0.25: R150.2@35.55,54.05 R149.1@36.55,54.05 36.53,54.03 U32.7@36.53,52.3
NetR154_1: R154.1 R155.1 U35.3 | length 3.8
  Bottom Layer w0.15: R155.1@13.444,26.156 14,26.713 14,27.704 U35.3@14.026,27.731 15.981,27.731 R154.1@16,27.75
NetR156_1: R156.1 U35.5 | length 2
  Bottom Layer w0.15: R156.1@9.85,27.9 9.85,27.95 10.275,28.375 10.325,28.375 10.631,28.681 U35.5@11.516,28.681
NetR158_1: R158.1 R161.1 U37.5 | length 10.3
  Bottom Layer w0.15: R161.1@108.717,53.4 109.45,53.4 110.05,54 R158.1@111.3,54 111.3,54.9 112.948,56.548 115.584,56.548 115.975,56.157 U37.5@115.975,55.073
NetR159_1: R159.1 R163.1 U38.5 | length 9.1
  Bottom Layer w0.15: R159.1@111.3,77.053 111.3,78.022 112.253,78.975 115.387,78.975 115.475,78.887 U38.5@115.475,78.126
  Bottom Layer w0.25: R163.1@108.7,76.75 109.3,76.75 109.603,77.053 R159.1@111.3,77.053
NetR176_2: R176.2 U44.4 | length 6.5
  Bottom Layer w0.15: R176.2@91.55,70.6 92.2,69.95 94.55,69.95 94.8,69.7 94.8,68.2 94.628,68.028 U44.4@93.45,68.028
NetR177_1: R177.1 U44.5 | length 1.7
  Bottom Layer w0.25: R177.1@91.75,69.318 93.43,69.318 U44.5@93.45,69.298
NetR178_2: R178.2 U46.4 | length 2
  Bottom Layer w0.25: R178.2@91.6,91.653 92.479,91.653 92.625,91.507 92.625,91.493 92.8,91.318 U46.4@93.45,91.318
NetR179_1: R179.1 U46.5 | length 1.9
  Bottom Layer w0.25: R179.1@91.6,92.553 93.415,92.553 U46.5@93.45,92.588
NetR182_2: R182.2 U47.7 U47.8 | length 7.1
  Bottom Layer w0.15: R182.2@86.15,48.545 86.429,48.824 87.275,48.824 87.436,48.985 87.867,48.985 88.932,50.05 ; U47.7@89,51.59 89,50.118 88.932,50.05 ; U47.8@89.65,51.59 89.65,50.35 89.35,50.05 89,50.05 88.932,50.05
NetR186_1: R186.1 R241.2 U50.3 | length 9.4
  Top Layer w0.25: v1(93.384,26.662) 92.95,27.096 R186.1@92.95,28.15 93.8,28.15 93.935,28.285 96.159,28.285 U50.3@96.191,28.252
  Bottom Layer w0.25: v1(93.384,26.662) 94.795,26.662 95.433,27.3 R241.2@97.5,27.3
NetR187_1: R187.1 U49.5 | length 1.7
  Bottom Layer w0.25: R187.1@92.522,32.723 92.557,32.758 U49.5@94.172,32.758
NetR188_2: R188.2 U49.4 | length 1.7
  Bottom Layer w0.25: R188.2@92.522,31.523 92.557,31.488 U49.4@94.172,31.488
NetR189_1: R189.1 U50.7 U52.4 | length 17.7
  Top Layer w0.15: U50.7@101.66,29.53 v1(105.242,29.53) 105.862,30.15 111.8,30.15 112.955,28.995 U52.4@112.955,27.869
  Bottom Layer w0.15: R189.1@100.7,29.5 100.73,29.53 v1(105.242,29.53)
NetR191_1: R191.1 U53.5 | length 1.9
  Bottom Layer w0.25: R191.1@92.5,44.607 92.504,44.603 U53.5@94.35,44.603
NetR192_2: R192.2 U53.4 | length 1.9
  Bottom Layer w0.25: R192.2@92.5,43.307 92.526,43.333 U53.4@94.35,43.333
NetR193_1: R193.1 U62.1 | length 1.4
  Top Layer w0.15: R193.1@90.255,89.348 U62.1@90.255,90.748
NetR193_2: R193.2 U60.2 | length 1.2
  Top Layer w0.15: U60.2@90.255,87.198 R193.2@90.255,88.348
NetR194_1: R194.1 U63.1 | length 1.4
  Top Layer w0.15: R194.1@83.325,89.3 U63.1@83.325,90.7
NetR194_2: R194.2 U61.2 | length 1.2
  Top Layer w0.15: U61.2@83.325,87.15 R194.2@83.325,88.3
NetR195_1: R195.1 U60.4 | length 1.6
  Top Layer w0.15: R195.1@89.205,83.848 89.205,84.673 89.605,85.073 U60.4@89.605,85.298
NetR196_1: R196.1 U61.4 | length 1.6
  Top Layer w0.15: R196.1@82.275,83.8 82.275,84.625 82.675,85.025 U61.4@82.675,85.25
NetR203_1: R203.1 R204.2 U65.7 | length 2.8
  Bottom Layer w0.15: U65.7@20.725,96.915 20.76,96.95 R203.1@22.625,96.95 R204.2@22.625,96.05
NetR204_1: R204.1 R205.2 | length 0.9
  Bottom Layer w0.15: R205.2@23.625,95.15 R204.1@23.625,96.05
NetR206_2: R206.2 U64.5 | length 1.3
  Bottom Layer w0.15: U64.5@6.705,96.028 R206.2@8.031,96.028
NetR211_1: R211.1 R212.2 U8.17 | length 4
  Bottom Layer w0.15: U8.17@33.711,29.695 33.738,29.722 33.738,30.388 34.2,30.85 R212.2@36.05,30.85 ; R211.1@36.05,29.95 R212.2@36.05,30.7
NetR213_1: R213.1 R216.2 | length 1.6
  Bottom Layer w0.25: R216.2@17.831,15.35 R213.1@19.39,15.35
NetR213_2: R213.2 U68.5 | length 1.8
  Bottom Layer w0.15: R213.2@19.39,17.05 19.611,17.271 U68.5@19.611,18.745
NetR215_2: R215.2 U16.1 | length 2.5
  Top Layer w0.15: U16.1@43.65,40.825 44.287,40.825 44.562,40.55 v1(44.6,40.55)
  Bottom Layer w0.15: R215.2@43.35,41 43.8,41 44.204,40.596 44.554,40.596 v1(44.6,40.55)
NetR222_2: R222.2 U16.10 | length 1.5
  Top Layer w0.15: U16.10@43.65,44.425 45.075,44.425 R222.2@45.1,44.4
NetR234_2: R234.2 U20.7 U22.1 | length 6.3
  Top Layer w0.15: U20.7@112.28,7.795 113.455,7.795 113.653,7.597 113.653,7.148 v1(113.64,7.135) ; v1@113.7,7.15 113.7,7.103 114.022,6.781 114.022,5.542 114.249,5.315 U22.1@114.7,5.315
  Bottom Layer w0.25: R234.2@111.816,7.176 111.856,7.135 v1(113.64,7.135)
NetR235_2: R235.2 U20.6 U22.4 | length 9.8
  Top Layer w0.15: U20.6@112.08,6.58 112.338,6.322 113.158,6.322 113.522,5.958 113.522,4.922 113.275,4.675 113.275,3.975 v1(113.2,3.9) 113.2,1.803 113.498,1.505 U22.4@114.7,1.505
  Bottom Layer w0.25: R235.2@111.6,5.015 111.6,4.715 112.415,3.9 v1(113.2,3.9)
NetR238_2: R238.2 U21.7 U23.1 | length 5.4
  Top Layer w0.15: U21.7@101.181,20.235 101.816,20.235 102.058,20.478 102.058,20.574 102.148,20.664 102.414,20.664 v1(102.5,20.75) 102.586,20.664 102.813,20.664 102.923,20.554 102.923,20.442 103.165,20.2 U23.1@103.8,20.2
  Bottom Layer w0.15: R238.2@100.7,21.8 101.45,21.8 v1(102.5,20.75)
NetR239_2: R239.2 U21.6 U23.4 | length 6.7
  Top Layer w0.15: U21.6@101.181,18.965 102.285,18.965 102.49,18.76 v1(102.49,17.014) 102.871,16.632 103.59,16.632 103.816,16.406 U23.4@103.8,16.39
  Bottom Layer w0.15: R239.2@100.7,17.4 102.103,17.4 v1(102.49,17.014)
NetR241_1: R241.1 U50.6 U52.1 | length 13.2
  Top Layer w0.2: U50.6@101.652,28.252 104.757,28.252 104.767,28.242 104.958,28.242 v1(105.5,27.7) 107.7,27.7 107.869,27.869 U52.1@109.145,27.869
  Bottom Layer w0.2: R241.1@100.7,27.3 101.652,27.3 102.605,28.252 104.757,28.252 104.767,28.242 104.958,28.242 v1(105.5,27.7)
NetR242_1: R242.1 U51.7 U52.3 | length 20.9
  Top Layer w0.2: U51.7@101.652,35.298 101.686,35.264 102.788,35.264 103.402,34.65 v1(105.804,34.65)
  Top Layer w0.25: U52.3@111.685,27.869 v1@111.685,29.309
  Bottom Layer w0.15: v1(105.804,34.65) 108.979,34.65 111.693,31.936 v1(111.693,29.317)
  Bottom Layer w0.2: R242.1@100.7,33.9 101.6,33.9 102.35,34.65 v1(105.804,34.65)
NetR245_1: R245.1 U55.7 U56.10 | length 14.4
  Top Layer w0.15: U55.7@101.831,47.464 103.036,47.464 103.807,46.693 106.443,46.693 106.773,47.023 107.173,47.023 v1(107.85,47.7)
  Bottom Layer w0.15: R245.1@100.7,48.118 101.462,48.118 101.85,47.73 105.28,47.73 105.625,48.075 107.475,48.075 v1(107.85,47.7)
NetR246_1: R246.1 U55.6 U56.9 | length 16.9
  Top Layer w0.15: U55.6@101.831,46.194 101.766,46.259 100.741,46.259 100.55,46.45 100.55,47.9 100.768,48.118 103.082,48.118 103.857,47.343 U56.9@105.225,47.343 105.256,47.374 106.237,47.374 106.325,47.462 106.325,48.675 v1(105.45,49.55)
  Bottom Layer w0.25: R246.1@100.7,50.318 101.682,50.318 102.8,49.2 104.2,49.2 104.55,49.55 v1(105.45,49.55)
NetR247_1: R247.1 U54.7 U56.11 | length 15.7
  Top Layer w0.15: U54.7@101.808,41.664 103.114,41.664 103.6,42.15 103.6,45.6 104.043,46.043 U56.11@105.225,46.043 106.643,46.043 v1(107,46.4)
  Bottom Layer w0.25: R247.1@100.7,45.918 101.918,45.918 102.448,46.448 104.914,46.448 104.962,46.4 v1(107,46.4)
NetR248_1: R248.1 U54.6 U56.12 | length 17.8
  Top Layer w0.15: U54.6@101.808,40.394 103.194,40.394 103.95,41.15 103.95,45.15 104.193,45.393 U56.12@105.225,45.393 106.307,45.393 106.9,44.8 v1(107.35,44.8)
  Bottom Layer w0.15: R248.1@100.7,43.718 100.7,44.018 101.125,44.443 101.213,44.443 101.898,45.128 105.398,45.128 105.721,44.805 105.721,44.801 105.809,44.713 107.037,44.713 107.038,44.714 107.264,44.714 v1(107.35,44.8)
NetR272_1: R272.1 U16.21 | length 4.8
  Top Layer w0.15: R272.1@40.35,38.2 40.35,38.75 39.9,39.2 39.9,39.65 40.3,40.05 41.1,40.05 41.325,40.275 41.325,41.125 41.425,41.225 U16.21@41.95,41.225
NetR273_2: R273.2 U48.21 | length 2.3
  Bottom Layer w0.15: R273.2@62.85,59.85 63.075,59.625 63.075,59.575 63.358,59.292 63.708,59.292 63.8,59.2 64.168,59.2 64.375,59.407 64.375,59.775 U48.21@64.4,59.8
NetR274_1: R274.1 U48.1 | length 6.3
  Bottom Layer w0.15: R274.1@61.6,63.6 61.6,64.4 62.2,65 62.85,65 63.55,64.3 63.55,62.559 64,62.109 U48.1@64,61.5
NetR275_1: R275.1 U48.10 | length 6.9
  L2-Signal w0.15: v1(68.35,61.95) 69.2,61.95 69.75,61.4 v1(69.75,59.6)
  Bottom Layer w0.15: U48.10@67.6,61.5 67.625,61.525 67.625,61.862 67.713,61.95 v1(68.35,61.95) ; v1(69.75,59.6) 71.4,61.25 R275.1@71.45,61.25
NetRA6_1: RA6.1 RA6.3 RA6.7 | length 4.5
  Bottom Layer w0.15: RA6.1@111.3,60.5 111.125,60.675 110.875,60.675 110.6,60.95 110.6,61.8 110.766,61.966 111.166,61.966 RA6.3@111.3,62.1 111.434,61.966 111.834,61.966 112.35,61.45 112.75,61.45 RA6.7@112.9,61.3
NetRA7_1: RA7.1 RA7.3 RA7.7 | length 4.5
  Bottom Layer w0.15: RA7.1@111.1,83.75 110.925,83.925 110.675,83.925 110.4,84.2 110.4,85.05 110.566,85.216 110.966,85.216 RA7.3@111.1,85.35 111.234,85.216 111.634,85.216 112.15,84.7 112.55,84.7 RA7.7@112.7,84.55
NetU8_20: U8.20 X13.1 | length 5.5
  Bottom Layer w0.15: U8.20@34.459,28.147 35.597,28.147 36.025,28.575 39.023,28.575 X13.1@39.548,28.05
OVRCRRn: R15.1 R217.2 U8.30 | length 25.9
  L1-Signal w0.15: v1(23.555,19.619) 26.231,19.619 26.325,19.525 31.825,19.525 32.5,20.2 37.05,20.2 37.65,20.8 37.65,21.639 37.475,21.814 37.475,22.775 v1(37.4,22.85)
  Bottom Layer w0.15: R217.2@22.15,20.45 22.85,20.45 23.469,19.831 23.469,19.705 v1(23.555,19.619) ; U8.30@34.459,24.147 34.486,24.12 34.925,24.12 34.998,24.047 35.151,24.047 35.873,23.325 35.873,21.845 36.758,20.961 36.789,20.961 R15.1@37.05,20.7 37.5,21.15 37.5,22.628 37.4,22.728 v1(37.4,22.85)
PCIE_CLK_N: J8.11 M1.226 | length 52.5
  Top Layer w0.2: v1(31.65,87.55) 31.65,87.442 31.85,87.242 31.85,86.205 33.005,85.05 36.505,85.05 38.55,83.005 38.55,82.35 39.65,81.25 41.9,81.25 52.954,70.196 66.009,70.196 67.105,69.1 69.055,69.1 69.825,68.33 69.825,67.54 70.575,66.79 70.575,66.624 70.55,66.599 70.55,65.65 M1.226@70.5,65.6
  Bottom Layer w0.2: J8.11@31.6,89.6 31.8,89.4 31.8,88.476 31.825,88.451 31.825,87.833 31.65,87.658 v1(31.65,87.55)
PCIE_CLK_P: J8.13 M1.228 | length 52.5
  Top Layer w0.2: v1(32.4,87.55) 32.4,87.442 32.2,87.242 32.2,86.35 32.35,86.2 33.15,85.4 36.65,85.4 38.9,83.15 38.9,82.495 39.795,81.6 42.045,81.6 53.099,70.546 66.154,70.546 67.25,69.45 69.2,69.45 70.175,68.475 70.175,67.685 70.925,66.935 70.925,66.624 70.95,66.599 70.95,65.65 M1.228@71,65.6
  Bottom Layer w0.2: v1(32.4,87.55) 32.4,87.658 32.175,87.883 32.175,88.451 32.2,88.476 32.2,89.4 J8.13@32.4,89.6
PCIE_RESET#: M1.244 R276.1 U48.4 | length 20.3
  Top Layer w0.15: M1.244@75,65.6 75.012,65.588 75.012,64.463 75.425,64.05 76.187,64.05 76.387,63.85 v1(76.5,63.85)
  L3-Signal w0.15: v1(65.05,62.7) 65.05,63.2 66.5,64.65 68.05,64.65 69.125,63.575 76.225,63.575 v1(76.5,63.85)
  Bottom Layer w0.15: v1(65.05,62.7) 65.1,62.65 65.1,62.1 65.2,62 U48.4@65.2,61.35 ; v1(76.5,63.85) 76.85,63.5 78.9,63.5 R276.1@79.169,63.769
PCIE_RESET_3V: D19.3 U48.18 | length 32.7
  Top Layer w0.15: D19.3@47.6,45.4 48.3,45.4 48.5,45.6 v1(48.5,46)
  L3-Signal w0.15: v1(48.5,46) 48.5,47.25 52,50.75 52,51.9 50.45,53.45 50.45,54.75 54.05,58.35 55.85,58.35 57.45,56.75 v1(57.45,55.95)
  Bottom Layer w0.15: v1(57.45,55.95) 57.45,56.45 58.7,57.7 64.15,57.7 65.6,59.15 U48.18@65.6,59.95
PCIE_RX_N: J8.23 M1.232 | length 46.5
  Top Layer w0.2: v1(39.65,87.65) 39.65,87.542 39.85,87.342 39.85,86.65 40.999,85.501 42.8,83.7 42.8,82.2 53.7,71.3 67.905,71.3 68.905,70.3 69.805,70.3 70.95,69.155 70.95,68.255 72.075,67.13 72.075,66.624 72.05,66.599 72.05,65.65 M1.232@72,65.6
  Bottom Layer w0.2: J8.23@39.6,89.6 39.8,89.4 39.8,88.476 39.825,88.451 39.825,87.933 39.65,87.758 v1(39.65,87.65)
PCIE_RX_P: J8.25 M1.234 | length 46.5
  Top Layer w0.2: v1(40.4,87.65) 40.4,87.542 40.2,87.342 40.2,86.795 41.144,85.851 42.031,84.964 42.147,84.847 43.15,83.845 43.15,82.345 53.845,71.65 68.05,71.65 69.05,70.65 69.95,70.65 71.3,69.3 71.3,68.4 72.425,67.275 72.425,66.624 72.45,66.599 72.45,65.65 M1.234@72.5,65.6
  Bottom Layer w0.2: v1(40.4,87.65) 40.4,87.758 40.175,87.983 40.175,88.451 40.2,88.476 40.2,89.4 J8.25@40.4,89.6
PCIE_TX_N: J8.31 M1.238 | length 45.9
  Top Layer w0.2: v1(42.85,87.7) 42.85,87.592 43.05,87.392 43.05,86.155 44.75,84.455 44.75,82.05 54.4,72.4 69.655,72.4 72.1,69.955 72.1,68.655 73.575,67.18 73.575,66.624 73.55,66.599 73.55,65.65 M1.238@73.5,65.6
  Bottom Layer w0.2: J8.31@42.8,89.6 43,89.4 43,88.476 43.025,88.451 43.025,87.983 42.85,87.808 v1(42.85,87.7)
PCIE_TX_P: J8.33 M1.240 | length 45.9
  Top Layer w0.2: v1(43.6,87.7) 43.6,87.592 43.4,87.392 43.4,86.3 44.5,85.2 44.616,85.084 45.1,84.6 45.1,82.195 54.545,72.75 69.8,72.75 72.45,70.1 72.45,68.8 73.925,67.325 73.925,66.624 73.95,66.599 73.95,65.65 M1.240@74,65.6
  Bottom Layer w0.2: v1(43.6,87.7) 43.6,87.808 43.375,88.033 43.375,88.451 43.4,88.476 43.4,89.4 J8.33@43.6,89.6
PERST#: J8.22 R146.2 R148.2 | length 5.3
  Bottom Layer w0.15: J8.22@39.2,81.4 39.3,81.3 R146.2@39.3,79.3 39.963,78.638 39.963,77.838 40.9,76.9 R148.2@40.95,76.9
PIRQ#: R10.1 U3.18 X8.1 | length 4.5
  Bottom Layer w0.15: U3.18@77.15,70.95 77.275,71.075 78.217,71.075 78.342,70.95 78.788,70.95 R10.1@78.838,71 78.838,71.543 78.882,71.587 79.734,72.44 80.34,72.44 X8.1@80.55,72.65
PR_OUT1A: D14.2 J5.3 PTC1.2 | length 108.2
  L3-Signal w0.5: v1(85.6,95.15) 85.6,96.35 92.55,103.3 96.276,103.3 120.71,103.3 129.15,94.86 129.15,60.85 v1(126.86,58.56)
  Bottom Layer w0.5: PTC1.2@78.25,89.016 79.097,89.016 79.737,89.656 79.737,90.23 84.657,95.15 v1(85.6,95.15) ; J5.3@121.4,61.5 123.1,61.5 124.8,59.8 124.8,57.95 125.515,57.235 D14.2@126.85,57.235 v1@126.85,58.55
PR_OUT1B: D14.1 J5.4 PR1.3 | length 122.4
  L3-Signal w0.5: v1(77.45,78.75) 74.4,81.8 74.4,83.3 85.45,94.35 87.5,94.35 89.425,96.275 89.425,97.875 94.1,102.55 120.483,102.55 128.35,94.683 128.35,61.45 v1(126.84,59.94)
  Bottom Layer w0.5: PR1.3@74.25,77.47 77.02,77.47 77.45,77.9 v1(77.45,78.75) ; J5.4@118.9,61.5 120.7,63.3 123.35,63.3 125.385,61.265 D14.1@126.85,61.265 v1@126.85,59.95
PR_OUT2A: D15.2 J5.5 PTC2.2 | length 91.7
  L3-Signal w0.5: v1(84.55,92.05) 85.95,93.45 87.75,93.45 91.1,96.8 91.89,96.8 92.3,97.21 92.3,97.78 96.27,101.75 120.081,101.75 127.56,94.271 127.56,65.86 v1(126.86,65.16)
  Bottom Layer w0.5: PTC2.2@82.25,89.016 82.25,90.8 83.5,92.05 v1(84.55,92.05) ; J5.5@121.4,65 123.75,65 124.915,63.835 D15.2@126.85,63.835 v1@126.85,65.15
PR_OUT2B: D15.1 J5.6 PR2.3 | length 101.7
  L3-Signal w0.5: v1@75.509,82.839 83.82,91.15 85.2,91.15 86.65,92.6 88.45,92.6 91.15,95.3 91.69,95.3 94.128,97.739 94.128,98.361 96.567,100.8 119.9,100.8 126.7,94 126.7,86.1 125.9,85.3 125.9,67.48 v1(126.84,66.54)
  Bottom Layer w0.5: PR2.3@74.26,82.82 v1(75.49,82.82) ; J5.6@118.9,65 120.7,66.8 122.7,66.8 123.765,67.865 D15.1@126.85,67.865 v1@126.85,66.55
PR_OUT3A: D16.2 J5.7 PTC3.2 | length 78.9
  L2-Signal w0.5: v1(89.9,103.15) 120.51,103.15 129.1,94.56 129.1,74 v1(126.86,71.76)
  Bottom Layer w0.5: PTC3.2@85.516,102 87.3,102 88.45,103.15 v1(89.9,103.15) ; J5.7@121.4,68.5 121.45,68.55 122.7,68.55 124.585,70.435 D16.2@126.85,70.435 v1@126.85,71.75
PR_OUT3B: D16.1 J5.8 PR3.3 | length 103.9
  L2-Signal w0.5: v1(73.01,88.1) 73.01,94.91 80.4,102.3 120.441,102.3 128.4,94.341 128.4,74.7 v1(126.84,73.14)
  Bottom Layer w0.5: v1(73.01,88.1) PR3.3@74.24,88.1 ; J5.8@118.9,68.5 120.7,70.3 122.2,70.3 124.85,72.95 124.85,73.8 125.515,74.465 D16.1@126.85,74.465 v1@126.85,73.15
PR_OUT4A: D17.2 J5.9 PTC4.2 | length 73
  L2-Signal w0.5: v1(88.8,101.55) 120.211,101.55 127.6,94.161 127.6,79.05 v1(126.86,78.31)
  Bottom Layer w0.5: PTC4.2@85.516,98 85.716,98.2 86.9,98.2 88.8,100.1 v1(88.8,101.55) ; J5.9@121.4,72 124.1,74.7 124.1,75.6 125.485,76.985 D17.2@126.85,76.985 v1@126.85,78.3
PR_OUT4B: D17.1 J5.10 PR4.3 | length 89.3
  L2-Signal w0.5: v1(74.25,94.7) 80.3,100.75 119.95,100.75 126.85,93.85 126.85,85.95 125.75,84.85 125.75,80.78 v1(126.84,79.69)
  Bottom Layer w0.5: PR4.3@74.25,93.47 v1(74.25,94.7) ; J5.10@118.9,72 120.7,73.8 121.616,73.8 123,75.184 123,78.6 125.415,81.015 D17.1@126.85,81.015 v1@126.85,79.7
PWM_3_DSI: J15.18 M1.19 R201.1 R202.2 X79.1 | length 52.4
  Top Layer w0.15: J15.18@4.081,83.978 4.092,83.989 15.201,83.989 15.69,83.5 16.5,83.5 16.85,83.85 v1(16.85,83.95) ; v1(10.825,65.8) 10.825,64.601 12.276,63.15 12.976,63.15 15.8,60.326 15.8,59.624 16.75,58.674 M1.19@16.75,57.4 16.75,56.1 16.6,55.95 15.07,55.95 X79.1@14.02,54.9
  L1-Signal w0.15: v1(10.825,65.8) 10.825,72.925 16.4,78.5 16.4,83.5 v1(16.85,83.95)
  Bottom Layer w0.15: R201.1@15.9,85.775 R202.2@16.85,85.775 v1(16.85,83.95)
PWR1: D26.1 J5.17 PTC8.2 | length 45.9
  Bottom Layer w0.5: PTC8.2@97.166,102.3 99.426,102.3 102.326,99.4 122.75,99.4 125.683,96.468 ; J5.17@121.4,86 122.8,86 127.015,90.215 D26.1@127.015,96.45 127.007,96.458 125.693,96.458
PWR2: D23.1 J5.18 PTC7.2 | length 55.9
  Top Layer w0.5: PTC7.2@97.166,102.3 98.838,102.3 100.588,100.55 115.35,100.55 117.6,98.3 126.218,98.3 127.8,96.718 127.8,85.5 v1(126.86,84.56)
  Bottom Layer w0.5: J5.18@118.9,86 120.7,84.2 122.166,84.2 123.131,83.235 D23.1@126.85,83.235 v1@126.85,84.55
PWR_1V8: L3.2 M1.214 | length 12.9
  Top Layer w0.3: v1(67.25,63.925) 67.25,64.006 67.5,64.256 M1.214@67.5,65.6
  L2-Signal w0.6: v1(67.25,63.925) 67.25,60.55 v1(69,58.8)
  Bottom Layer w0.6: L3.2@66.3,54.64 66.3,56.1 v1(69,58.8)
PWR_EN: J2.5 R5.1 R6.1 R27.2 U10.1 U64.3 X15.1 | length 143.5
  Top Layer w0.15: X15.1@83.55,66.715 83.77,66.935 84.197,66.935 84.213,66.95 85.05,66.95 85.05,67.4 85.15,67.5 R6.1@85.15,68.65 85.945,68.65 86.27,68.325 U10.1@86.75,68.325 ; R6.1@85.15,68.7 R5.1@85.15,70.2
  L1-Signal w0.15: J2.5@56.535,52.505 55.63,51.6 53.482,51.6 53.2,51.882 53.2,57.3 58.95,63.05 58.95,64.8 59.85,65.7 82.535,65.7 X15.1@83.55,66.715
  L3-Signal w0.15: v1(5.2,96.978) 6.375,95.803 9.667,95.803 10.42,95.05 15.05,95.05 33.85,76.25 38.042,76.25 39.5,74.792 39.5,71.9 41.6,69.8 44.875,66.525 53.174,66.525 64.7,54.999 64.7,52.592 63.341,51.233 63.025,51.233 61.678,49.885 59.155,49.885 J2.5@56.535,52.505
  Bottom Layer w0.25: U64.3@4.195,96.978 v1(5.2,96.978)
PWR_EN#: Q11.5 Q11.6 R16.1 U8.29 | length 26.9
  L1-Signal w0.15: v1(23.45,17.7) 23.5,17.65 31.2,17.65 33.25,19.7 37.543,19.7 37.95,20.107 37.95,23.2 37.61,23.54 37.233,23.54 v1(37.2,23.573)
  Bottom Layer w0.15: R16.1@22.25,15.35 22.475,15.575 22.475,15.786 22.55,15.861 22.55,16.225 Q11.6@22.525,16.25 23.062,16.25 23.15,16.338 23.15,16.75 ; Q11.5@22.525,16.75 23.15,16.75 ; v1(23.45,17.7) 23.45,17.05 23.15,16.75 ; U8.29@34.459,24.547 34.486,24.52 34.949,24.52 35.11,24.359 35.984,24.359 36.15,24.525 36.635,24.525 37.172,23.988 37.172,23.601 v1(37.2,23.573)
PWR_USB: Q11.3 R223.1 U68.3 | length 19
  Top Layer w0.15: R223.1@17.96,24.704 18.004,24.704 18.675,25.375 18.767,25.375 19.075,25.683 19.075,25.775 v1(19.4,26.1)
  L1-Signal w0.15: v1(17.45,22.05) 17.45,23.9 19.4,25.85 v1(19.4,26.1)
  Bottom Layer w0.15: v1(17.45,22.05) 17.45,21.626 17.975,21.101 17.975,20.553 18.528,20 20.561,20 ; U68.3@20.561,21.255 20.561,20 ; Q11.3@21.175,17.25 21.175,17.816 21.308,17.949 22.717,17.949 22.9,18.132 22.9,19.368 22.668,19.6 21.411,19.6 21.011,20 20.561,20
REL1: M1.60 Q5.1 R106.2 | length 48.2
  Top Layer w0.15: M1.60@27,65.6 27,67.05 28.65,68.7 28.65,73.65 v1(34.55,79.55)
  L1-Signal w0.15: v1(34.55,79.55) 35.075,79.025 37.174,79.025 38.249,80.1 48.7,80.1 49.1,80.5 52.75,80.5 55.05,78.2 55.05,76.088 v1(56.138,75)
  Bottom Layer w0.15: v1@56.139,74.999 Q5.1@57.147,74.999 57.222,74.999 58.897,76.674 R106.2@58.897,78.449
REL2: M1.62 Q6.1 R107.2 | length 44.2
  Top Layer w0.15: M1.62@27.5,65.6 27.5,67.126 28.95,68.576 28.95,73.208 35.3,79.558 v1(35.3,79.65)
  L1-Signal w0.15: v1(35.3,79.65) 35.392,79.65 35.717,79.325 37.049,79.325 38.124,80.4 48.576,80.4 48.976,80.8 55.6,80.8 v1(56,80.4)
  Bottom Layer w0.15: v1@56.001,80.399 Q6.1@57.047,80.399 57.122,80.399 58.847,82.124 R107.2@58.847,83.849
REL3: M1.64 Q7.1 R108.2 | length 45.8
  Top Layer w0.15: M1.64@28,65.6 28,67.201 29.25,68.451 29.25,72.858 36.15,79.758 v1(36.15,79.85)
  L1-Signal w0.15: v1(36.15,79.85) 37.15,79.85 38,80.7 48.451,80.7 48.851,81.1 52.074,81.1 56,85.026 v1(56,85.75)
  Bottom Layer w0.15: v1@56.001,85.749 Q7.1@57.047,85.749 57.122,85.749 58.897,87.524 R108.2@58.897,89.349
  Bottom Layer w0.25: v1(56,85.75) v1@56.001,85.749
REL4: M1.66 Q8.1 R109.2 | length 50.8
  Top Layer w0.15: M1.66@28.5,65.6 28.5,67.277 29.55,68.327 29.55,72.508 36.85,79.808 v1(36.85,80.6)
  L1-Signal w0.15: v1(36.85,80.6) 37.476,80.6 37.876,81 48.327,81 48.727,81.4 51.95,81.4 54.9,84.35 54.9,90.125 v1(56.075,91.3)
  Bottom Layer w0.15: v1@56.076,91.299 Q8.1@57.047,91.299 57.122,91.299 58.897,93.074 58.897,94.027 R109.2@58.897,94.849
RGMII.RGMII_INT#: M1.189 R221.1 U26.44 | length 59.5
  Top Layer w0.15: R221.1@53.25,22.35 53.255,22.355 v1(53.995,22.355) ; M1.189@61.25,57.4 61.25,56.25 61.95,55.55 v1(61.95,55.35)
  L1-Signal w0.15: v1(53.995,22.355) 53.995,22.445 53.625,22.815 53.625,25.667 51.817,27.475 46.883,27.475 45.575,28.783 45.575,31.275 47.4,33.1 50.717,33.1 51.017,33.4 51.75,33.4 54.6,36.25 54.6,37.35 61.7,44.45 61.7,49.45 63.5,51.25 64.5,51.25 65.3,52.05 65.3,54.2 63.9,55.6 62.2,55.6 v1(61.95,55.35)
  Bottom Layer w0.15: U26.44@51.4,23.325 52.435,23.325 53.41,22.35 53.991,22.35 v1(53.995,22.355)
RGMII.RGMII_MDC: M1.193 U26.16 | length 51.5
  Top Layer w0.25: v1(61.8,51.35) 62.13,51.68 63.227,51.68 63.8,52.253 63.8,54.4 63.475,54.725 63.475,55.261 63.436,55.3 63.436,55.313 62.5,56.25 62.486,56.25 62.275,56.461 62.275,57.375 M1.193@62.25,57.4
  L1-Signal w0.15: v1(47.35,34.15) 47.864,34.664 51.514,34.664 53.2,36.35 53.2,37.7 60.4,44.9 60.4,50.45 61.3,51.35 v1(61.8,51.35)
  Bottom Layer w0.25: U26.16@44.6,22.825 44.164,22.825 43.2,23.789 43.2,24.146 42.625,24.721 42.625,29.861 42.225,30.261 42.225,30.275 41.6,30.9 41.6,32.65 43.1,34.15 v1(47.35,34.15)
RGMII.RGMII_MDIO: M1.191 R220.1 U26.17 | length 50.9
  Top Layer w0.25: M1.191@61.75,57.4 61.75,56.363 62.861,55.251 v1(62.861,55.075)
  L1-Signal w0.15: v1(49.25,33.65) 49.325,33.575 50.133,33.575 50.233,33.475 50.667,33.475 50.892,33.7 51.55,33.7 54.1,36.25 54.1,37.45 61.25,44.6 61.25,49.55 63.66,51.96 63.66,54.34 62.925,55.075 v1(62.861,55.075)
  Bottom Layer w0.25: U26.17@44.6,23.325 44.23,23.325 43.65,23.905 43.65,24.3 43.15,24.8 43.15,29.95 42.928,30.172 42.928,30.547 42.211,31.264 42.211,32.35 43.436,33.575 44.695,33.575 45.4,33.575 cw(c45.4,33.285) 45.69,33.285 45.69,33.096 ccw(c45.98,33.096) 46.27,33.096 46.27,33.285 cw(c46.56,33.285) 46.56,33.575 47.456,33.575 49.175,33.575 v1(49.25,33.65)
RGMII.RGMII_RX_CTRL: M1.199 R118.2 R120.1 U26.38 | length 40.6
  Top Layer w0.25: M1.199@63.75,57.4 63.825,57.325 63.825,56.119 64.275,55.669 64.275,55.146 64.6,54.821 64.6,51.589 64.35,51.339 v1(64.35,49.5)
  L1-Signal w0.15: v1(53.9,30.85) 53.85,30.9 53.85,32.635 54.968,33.753 56.003,33.753 57.55,35.3 57.55,37.55 63.75,43.75 63.75,47.528 64.35,48.128 v1(64.35,49.5)
  Bottom Layer w0.25: U26.38@51.4,26.325 51.825,26.325 52.299,26.799 52.299,28.306 52.636,28.643 52.643,28.643 52.653,28.653 53.151,29.151 cw(c53.356,28.946) 53.561,29.151 53.683,29.03 ccw(c53.888,29.235) 54.093,29.03 ccw(c53.888,29.235) 54.093,29.44 53.972,29.561 cw(c54.177,29.767) 53.972,29.972 54.271,30.271 54.271,30.473 54.271,30.479 v1(53.9,30.85) ; R118.2@64.35,48.75 v1(64.35,49.5) R120.1@64.35,50.25
RGMII.RGMII_RXC: M1.197 U26.32 | length 40.8
  Top Layer w0.25: v1(61.291,50.41) 62.855,50.41 64.2,51.755 64.2,54.655 63.875,54.98 63.875,55.504 63.25,56.129 M1.197@63.25,57.4
  L1-Signal w0.15: v1(50.45,34) 51.4,34 53.65,36.25 53.65,37.55 60.85,44.75 60.85,49.969 v1(61.291,50.41)
  Bottom Layer w0.25: U26.32@48.75,27.475 48.75,27.9 48.845,27.995 48.845,28.761 49.933,29.848 49.933,30.493 49.933,31.778 ccw(c49.643,31.778) 49.643,32.068 48.688,32.068 cw(c48.688,32.358) 48.688,32.648 49.643,32.648 ccw(c49.643,32.938) 49.933,32.938 49.933,33.435 49.933,33.483 v1(50.45,34)
RGMII.RGMII_RXD_0: M1.201 R114.2 R115.1 U26.33 | length 40.2
  Top Layer w0.25: M1.201@64.25,57.4 64.25,56.26 64.675,55.835 64.675,55.312 65.3,54.687 v1(65.3,49.5)
  L1-Signal w0.15: v1(50.85,30.55) 50.921,30.621 51.221,30.621 56.3,35.7 56.3,36.85 63.35,43.9 63.35,49.242 64.133,50.025 64.775,50.025 v1(65.3,49.5)
  Bottom Layer w0.25: U26.33@49.25,27.475 49.25,28.6 50.798,30.148 50.798,30.498 v1(50.85,30.55) ; R114.2@65.35,48.75 65.35,49.45 v1(65.3,49.5) 65.3,50.2 R115.1@65.35,50.25
RGMII.RGMII_RXD_1: M1.203 U26.34 | length 39.8
  Top Layer w0.25: M1.203@64.75,57.4 64.75,56.326 65.075,56.001 65.075,55.82 65.35,55.545 v1(65.35,55.45)
  L1-Signal w0.15: v1(51.25,32.85) 51.3,32.9 51.775,32.9 55.05,36.175 55.05,37.25 62.1,44.3 62.1,49.3 63.725,50.925 64.599,50.925 65.6,51.926 65.6,54.324 65.35,54.574 v1(65.35,55.45)
  Bottom Layer w0.25: U26.34@49.75,27.475 49.75,28.319 51.55,30.119 51.55,31.044 51.55,31.169 ccw(c51.26,31.169) 51.26,31.459 50.623,31.459 cw(c50.623,31.749) 50.623,32.039 51.26,32.039 ccw(c51.26,32.329) 51.55,32.329 51.55,32.529 51.25,32.829 51.25,32.842 v1(51.25,32.85)
RGMII.RGMII_RXD_2: M1.205 R116.2 R117.2 U26.35 | length 40.6
  Top Layer w0.25: M1.205@65.25,57.4 65.25,56.391 65.475,56.166 65.475,56.138 66.35,55.263 66.35,53.255 66.95,52.655 66.95,50.454 66.4,49.904 66.4,49.55 v1(66.35,49.5)
  L1-Signal w0.15: v1(55.05,32.95) 55.553,33.453 56.127,33.453 57.95,35.276 57.95,37.35 63.75,43.15 64.1,43.15 64.9,43.95 64.9,45.5 65.829,46.429 65.829,48.979 v1(66.35,49.5)
  Bottom Layer w0.25: U26.35@50.25,27.475 50.25,28.1 52,29.85 52,31.65 53.3,32.95 v1(55.05,32.95) ; R116.2@66.35,48.75 v1(66.35,49.5) R117.2@66.35,50.25
RGMII.RGMII_RXD_3: M1.207 U26.36 | length 40.5
  Top Layer w0.25: M1.207@65.75,57.4 65.75,56.457 65.875,56.332 65.875,56.304 66.75,55.429 66.75,53.421 67.4,52.771 67.4,50.338 67.25,50.188 v1(67.25,49.5)
  L1-Signal w0.15: v1(56.025,32.7) 58.35,35.025 58.35,37.2 63.8,42.65 65.6,42.65 67.9,44.95 67.9,48.85 v1(67.25,49.5)
  Bottom Layer w0.25: U26.36@50.75,27.475 50.75,27.95 52.5,29.7 52.5,31.5 53.4,32.4 54.787,32.4 54.812,32.375 55.605,32.375 55.93,32.7 v1(56.025,32.7)
RGMII.RGMII_TX_CTRL: M1.211 U26.37 | length 47.5
  Top Layer w0.25: M1.211@66.75,57.4 66.75,55.995 67.15,55.595 67.15,53.586 67.8,52.936 67.8,50.075 v1(67.875,50)
  L1-Signal w0.15: v1(54.9,31.8) 58.45,31.8 62.85,36.2 62.85,38.25 63.033,38.433 63.086,38.486 ccw(c62.916,38.656) 63.086,38.825 62.548,39.363 ; 62.548,39.363 cw(c62.718,39.533) 62.548,39.702 cw(c62.718,39.533) 62.888,39.702 63.488,39.102 ccw(c63.658,39.272) 63.828,39.102 ccw(c63.658,39.272) 63.828,39.442 63.227,40.042 cw(c63.397,40.212) 63.227,40.381 cw(c63.397,40.212) 63.567,40.381 64.167,39.781 ccw(c64.337,39.951) 64.507,39.781 ccw(c64.337,39.951) 64.507,40.121 63.907,40.721 cw(c64.076,40.891) 63.907,41.061 cw(c64.076,40.891) 64.246,41.061 64.784,40.523 ccw(c64.953,40.693) 65.123,40.523 65.426,40.826 68.35,43.75 68.35,49.5 67.875,49.975 v1(67.875,50)
  Bottom Layer w0.25: U26.37@51.4,26.825 51.4,28.034 52.9,29.534 52.9,30.817 53.85,31.767 54.867,31.767 v1(54.9,31.8)
RGMII.RGMII_TXC: M1.213 U26.29 | length 46.6
  Top Layer w0.25: M1.213@67.25,57.4 67.25,56.06 67.55,55.76 67.55,54.35 v1(68.2,53.7)
  L1-Signal w0.15: v1(47.25,31.3) 47.722,31.3 47.797,31.3 ccw(c47.797,31.553) 48.05,31.553 48.05,31.772 cw(c48.303,31.772) 48.303,32.025 cw(c48.303,31.772) 48.556,31.772 48.556,31.428 ccw(c48.808,31.428) 48.808,31.175 ccw(c48.808,31.428) 49.061,31.428 49.061,31.772 cw(c49.314,31.772) 49.314,32.025 cw(c49.314,31.772) 49.567,31.772 49.567,31.553 ccw(c49.82,31.553) 49.82,31.3 51.023,31.3 51.3,31.3 55.85,35.85 55.85,36.95 62.9,44 62.9,49.217 64.008,50.325 66.773,50.325 66.988,50.54 66.988,50.913 67.213,51.138 67.586,51.138 67.85,51.402 67.85,51.9 68.052,52.102 68.55,52.102 68.8,52.352 68.8,52.65 68.6,52.85 68.288,52.85 68.2,52.938 v1(68.2,53.7)
  Bottom Layer w0.25: U26.29@47.25,27.475 47.25,28.087 47.425,28.262 47.425,31.125 v1(47.25,31.3)
RGMII.RGMII_TXD_0: M1.221 U26.28 | length 46.1
  Top Layer w0.25: M1.221@69.25,57.4 69.25,56.095 70.075,55.27 70.075,53.709 69.7,53.334 v1(69.7,52.2)
  L1-Signal w0.15: v1(46.85,28.5) 46.863,28.5 47.113,28.75 55.725,28.75 56.575,29.6 58.1,29.6 64.15,35.65 64.15,37.9 70.1,43.85 70.1,51.8 v1(69.7,52.2)
  Bottom Layer w0.25: U26.28@46.745,27.65 46.65,27.745 46.65,28.205 46.85,28.405 v1(46.85,28.5)
RGMII.RGMII_TXD_1: M1.219 U26.27 | length 46.8
  Top Layer w0.25: v1(68.55,51.3) 68.775,51.525 68.775,52.975 69.675,53.875 69.675,55.104 68.75,56.029 M1.219@68.75,57.4
  L1-Signal w0.15: v1(46.6,30.2) 46.722,30.2 47.022,29.9 53.9,29.9 55.5,31.5 58.7,31.5 63.35,36.15 63.35,38.2 68.75,43.6 68.75,49.9 68.55,50.1 v1(68.55,51.3)
  Bottom Layer w0.25: U26.27@46.25,27.475 46.25,28.787 46.675,29.212 46.675,29.688 46.657,29.707 46.657,30.143 v1(46.6,30.2)
RGMII.RGMII_TXD_2: M1.217 U26.26 | length 46.5
  Top Layer w0.25: M1.217@68.25,57.4 68.25,56.192 68.35,56.092 68.35,55.863 68.925,55.288 68.925,55.025 69.1,54.85 v1(69.1,54.4)
  L1-Signal w0.15: v1(46.1,29.45) 54.1,29.45 55.35,30.7 58.45,30.7 63.75,36 63.75,38.05 69.143,43.443 69.143,54.357 v1(69.1,54.4)
  Bottom Layer w0.25: U26.26@45.75,27.475 45.75,28.355 45.85,28.455 45.85,28.953 46.1,29.203 v1(46.1,29.45)
RGMII.RGMII_TXD_3: M1.215 U26.25 | length 46.8
  Top Layer w0.25: M1.215@67.75,57.4 67.75,56.126 67.95,55.926 67.95,55.45 v1(68.35,55.05)
  L1-Signal w0.15: v1(47.35,32.25) 47.425,32.325 51.775,32.325 55.45,36 55.45,37.1 62.5,44.15 62.5,49.241 63.884,50.625 66.025,50.625 67.416,52.016 67.416,54.116 v1(68.35,55.05)
  Bottom Layer w0.25: U26.25@45.25,27.475 45.25,28.577 45.45,28.777 45.45,30.35 45.603,30.503 45.692,30.592 ccw(c45.487,30.797) 45.692,31.002 44.761,31.933 cw(c44.966,32.138) 44.761,32.343 cw(c44.966,32.138) 45.171,32.343 46.102,31.412 ccw(c46.307,31.617) 46.512,31.412 v1(47.35,32.25)
RS232_CTS: J6.18 U56.8 U57.1 | length 10.7
  Top Layer w0.15: U56.8@110.775,47.343 110.775,48.025 v1(110.8,48.05)
  Bottom Layer w0.15: v1(110.8,48.05) 114,44.85 U57.1@115.05,44.85
  Bottom Layer w0.25: U57.1@115.05,44.85 116.2,44.85 117.55,43.5 J6.18@118.9,43.5
RS232_RTS: J6.17 U56.7 U57.2 | length 16.9
  Top Layer w0.15: v1(109.3,46.7) 110.768,46.7 U56.7@110.775,46.693
  Bottom Layer w0.15: v1(109.3,46.7) 111.612,46.7 114,44.312 114,43.1 114.15,42.95 U57.2@115.05,42.95
  Bottom Layer w0.25: U57.2@115.05,42.95 116.95,42.95 117.95,41.95 119.85,41.95 J6.17@121.4,43.5
RS232_RX: J6.16 U56.13 U58.2 | length 16.3
  Top Layer w0.15: U56.13@105.225,44.743 105.255,44.713 106.187,44.713 106.65,44.25 v1(108.05,44.25)
  Bottom Layer w0.15: v1(108.05,44.25) 110.246,42.054 110.246,41.824 112.295,39.775 112.525,39.775 112.95,39.35 U58.2@115.05,39.35
  Bottom Layer w0.25: U58.2@115.05,39.35 118.083,39.35 118.733,40 J6.16@118.9,40
RS232_TX: J6.15 U56.14 U58.1 | length 18.6
  Top Layer w0.15: U56.14@105.225,44.093 106.383,44.093 106.58,43.896 107.555,43.896 107.725,43.725 108.975,43.725 v1(109.35,44.1)
  Bottom Layer w0.15: v1(109.35,44.1) 109.35,43.374 110.682,42.042 113.167,42.042 113.186,42.061 113.311,42.061 114.122,41.25 U58.1@115.05,41.25
  Bottom Layer w0.25: U58.1@115.05,41.25 120.15,41.25 J6.15@121.4,40
RS485_N: J6.12 R190.1 U52.7 U59.1 | length 20.4
  Top Layer w0.15: U52.7@110.415,33.33 110.415,33.965 110.657,34.208 110.687,34.208 110.788,34.308 110.788,34.915 110.788,35.003 R190.1@110.563,35.228 112.06,36.725 114.525,36.725 115.775,35.475 115.775,33.638 115.863,33.55 U59.1@116.45,33.55 U59.1@116.31,33.41
  Top Layer w0.25: U59.1@116.31,33.41 116.31,31.079 116.15,30.92 116.15,30.849 115.775,30.474 115.775,29.938 115.863,29.85 116.55,29.85 116.8,30.1 116.8,30.8 117.5,31.5 118.396,31.5 118.858,31.963 118.858,32.958 J6.12@118.9,33
RS485_P: J6.10 J14.2 U52.6 U59.2 | length 17.7
  Top Layer w0.15: U52.6@111.685,33.33 111.685,33.965 112.72,35 113.22,35 J14.2@114.17,35.95 115.225,34.895 115.225,33.638 115.137,33.55 U59.2@114.55,33.55 U59.2@114.69,33.41
  Top Layer w0.25: U59.2@114.69,33.41 114.69,31.08 114.925,30.845 114.925,30.774 115.225,30.474 115.225,29.71 115.635,29.3 116.778,29.3 117.35,29.872 117.35,30.572 117.728,30.95 118.5,30.95 118.9,30.55 J6.10@118.9,29.5
SD1_CD#: J12.9 M1.84 R157.1 U36.5 U36.6 | length 51.7
  Top Layer w0.15: v1(13.05,33.7) 13.05,35.22 14.59,36.76 15.188,36.76 15.587,37.16 J12.9@15.587,37.185 ; M1.84@33,65.6 33,64.275 v1(33.025,64.25)
  L2-Signal w0.15: v1(32,51.15) 32.1,51.15 33.84,52.89 33.84,56.14 35.4,57.7 35.4,61.875 v1(33.025,64.25)
  Bottom Layer w0.15: v1(13.05,33.7) 13.05,34.333 U36.6@13.033,34.35 U36.5@13.867,34.35 13.917,34.4 15.453,34.4 ; R157.1@16.766,33.4 15.541,33.4 15.453,33.488 15.453,34.4 ; v1(32,51.15) 31.358,51.15 21.55,41.342 21.55,40.65 20.6,39.7 19.7,39.7 18.95,38.95 18.95,37.897 15.453,34.4
SD1_CLK: J12.5 M1.78 U34.4 U34.7 | length 60.2
  Top Layer w0.25: J12.5@4.503,36.085 5.585,36.085 5.85,36.35 5.85,36.8 6.35,37.3 7.5,37.3 7.95,37.75 7.95,40.3 8.875,41.225 10.275,41.225 v1(10.55,40.95) ; M1.78@31.5,65.6 v1(31.5,66.95)
  L2-Signal w0.15: v1(30.7,53.75) 31.95,53.75 32.5,54.3 32.5,54.65 32.5,54.725 32.4,54.825 31.625,54.825 31.525,54.925 31.525,55.225 31.625,55.325 32.619,55.325 32.719,55.425 32.719,55.725 32.619,55.825 30.686,55.825 30.586,55.925 30.586,56.225 30.686,56.325 32.6,56.325 32.7,56.425 32.7,56.725 32.6,56.825 32.5,56.925 32.5,57.583 32.5,57.819 32.1,58.219 32.1,62.1 31.45,62.75 31.45,64.467 31.5,64.517 v1(31.5,66.95)
  Bottom Layer w0.25: v1(10.55,40.95) 10.55,40.35 11.475,39.425 12.538,39.425 12.601,39.487 U34.7@13.008,39.488 14.312,39.488 14.387,39.412 14.863,39.412 17.63,42.179 18.997,42.179 24.423,47.606 24.423,48.473 26.375,50.425 27.454,50.425 30.7,53.671 v1(30.7,53.75)
SD1_CMD: J12.3 M1.74 U36.1 U36.10 | length 60.4
  Top Layer w0.25: J12.3@4.503,33.885 5.493,33.885 9.478,29.9 10.95,29.9 12.4,31.35 v1(12.4,32.1) ; M1.74@30.5,65.6 v1(30.5,66.95)
  L2-Signal w0.15: v1(27.621,49.479) 27.621,49.555 27.384,49.792 27.384,54.277 27.965,54.857 28.372,55.264 28.513,55.264 28.915,54.862 29.056,54.862 29.268,55.074 29.268,55.216 28.867,55.618 28.867,55.759 29.47,56.363 30.5,57.392 30.5,63.933 30.4,64.033 30.4,64.467 30.5,64.567 v1(30.5,66.95)
  Bottom Layer w0.25: v1(12.4,32.1) 11.3,33.2 11.3,35.729 11.921,36.35 U36.10@13.033,36.35 14.734,36.35 15.5,37.116 15.5,39.484 17.796,41.779 19.162,41.779 25.253,47.87 25.253,48.403 26.425,49.575 27.525,49.575 v1(27.621,49.479)
SD1_D0: J12.7 M1.80 U34.2 U34.9 | length 59.7
  Top Layer w0.25: J12.7@4.503,38.285 5.835,38.285 5.95,38.4 5.95,39.25 8.55,41.85 10.463,41.85 11.346,40.967 v2(11.346,40.946) ; v1(31.975,64.25) 32,64.275 M1.80@32,65.6
  L2-Signal w0.15: v1(29.3,53.9) 29.3,53 30.3,52 31.271,52 31.771,52.5 32.15,52.5 33.2,53.55 33.2,57.15 33.45,57.4 33.45,58.233 33.45,58.955 33.55,59.055 33.563,59.055 33.663,59.155 33.663,59.455 33.563,59.555 32.576,59.555 32.476,59.655 32.476,59.955 32.576,60.055 34.499,60.055 34.599,60.155 34.599,60.455 34.499,60.555 32.576,60.555 32.476,60.655 32.476,60.955 32.576,61.055 34.171,61.055 34.271,61.155 34.271,61.455 34.171,61.555 33.55,61.555 33.45,61.655 33.45,61.73 33.45,61.941 31.975,63.416 v1(31.975,64.25)
  Bottom Layer w0.25: v2(11.346,40.946) 11.717,40.575 12.538,40.575 12.626,40.488 U34.9@13.008,40.488 U34.2@13.842,40.488 13.917,40.562 15.112,40.562 17.129,42.579 18.831,42.579 23.6,47.349 23.6,48.45 25.975,50.825 26.225,50.825 v1(29.3,53.9)
SD1_D1: J12.8 M1.82 U34.1 U34.10 | length 59.5
  Top Layer w0.25: J12.8@4.503,39.385 4.726,39.609 5.459,39.609 8.2,42.35 11.05,42.35 11.753,41.647 v1(11.753,41.6) ; M1.82@32.5,65.6 v1(32.5,66.95)
  L2-Signal w0.15: v1(27.95,53.75) 27.95,52.75 29.173,51.527 29.3,51.4 29.525,51.4 29.625,51.3 29.625,50.65 29.725,50.55 30.025,50.55 30.125,50.65 30.125,51.417 30.225,51.517 30.525,51.517 30.625,51.417 30.625,50.587 30.725,50.487 31.025,50.487 31.125,50.587 31.125,51.3 31.225,51.4 31.3,51.4 31.302,51.4 31.952,52.05 32.5,52.05 33.5,53.05 33.5,56.4 35.05,57.95 35.05,61.2 32.5,63.75 v1(32.5,66.95)
  Bottom Layer w0.25: v1(11.753,41.6) 12.365,40.987 U34.10@13.008,40.987 U34.1@13.842,40.987 14.587,40.987 17.85,44.25 19.936,44.25 22.859,47.173 22.859,48.709 27.9,53.75 v1(27.95,53.75)
SD1_D2: J12.1 M1.70 U36.4 U36.7 | length 60.3
  Top Layer w0.25: J12.1@4.503,31.685 4.818,31.685 5.093,31.41 5.093,30.807 7.7,28.2 11.05,28.2 13.75,30.9 v1(13.75,32.85) ; M1.70@29.5,65.6 v1(29.5,66.95)
  L2-Signal w0.15: v1(26.65,47.5) 26.25,47.9 26.25,55.05 27.65,56.45 27.65,61.55 29.35,63.25 29.35,66.678 29.5,66.828 v1(29.5,66.95)
  Bottom Layer w0.25: v1(13.75,32.85) 13.087,32.85 12.168,33.768 12.168,34.405 12.613,34.85 U36.7@13.033,34.85 U36.4@13.867,34.85 14.3,34.85 14.4,34.75 14.906,34.75 18.6,38.444 18.6,39.94 19.212,40.552 19.212,40.599 20.463,41.85 21.563,41.85 23.45,43.737 23.45,44.348 26.602,47.5 v1(26.65,47.5)
SD1_D3: J12.2 M1.72 U36.2 U36.9 | length 60.4
  Top Layer w0.25: J12.2@4.902,32.785 5.252,32.785 5.527,32.51 5.527,32.199 7.377,30.35 7.377,29.573 8.1,28.85 10.8,28.85 12.975,31.025 12.975,32.1 v1(13.15,32.275) ; v1(29.875,64.25) 29.875,64.345 29.975,64.445 29.975,65.575 M1.72@30,65.6
  L2-Signal w0.15: v2(26.9,49) 26.9,54.5 29.1,56.7 29.1,59.475 29.1,59.55 29,59.65 28.318,59.65 28.218,59.75 28.218,60.05 28.318,60.15 29.641,60.15 29.741,60.25 29.741,60.55 29.641,60.65 28.61,60.65 28.51,60.75 28.51,61.05 28.61,61.15 29,61.15 29.1,61.25 29.1,61.999 29.1,62.25 29.875,63.025 v1(29.875,64.25)
  Bottom Layer w0.25: v1(13.15,32.275) 13.096,32.275 11.725,33.646 11.725,35.588 12.062,35.925 12.958,35.925 U36.9@13.033,35.85 14.362,35.85 14.462,35.95 14.9,35.95 16.65,37.7 16.65,40.068 17.961,41.379 19.372,41.379 26.9,48.907 v2(26.9,49)
SD1_PWR_EN: M1.76 R155.2 | length 48.5
  Top Layer w0.15: v1(30.925,64.25) 31,64.325 M1.76@31,65.6
  L1-Signal w0.15: v1(18.05,26.65) 18.087,26.687 18.087,27.893 18.091,27.896 18.091,30.016 18.6,30.526 18.6,32.95 22.2,36.55 23.55,36.55 25.95,38.95 25.95,54.2 27.5,55.75 28.1,55.75 30.55,58.2 30.55,63.875 v1(30.925,64.25)
  Bottom Layer w0.15: R155.2@15.15,26.25 16.307,26.25 16.707,26.65 v1(18.05,26.65)
SHLD: C102.2 H1.0 H2.0 H3.0 H4.0 R55.1 | length 7.8
  Top Layer w0.5: H2.0@3,102 4.353,102 5.653,103.3 C102.2@8,103.3 R55.1@10.3,103.3
SPI_CLK: J2.7 M1.196 U3.19 U6.6 X7.1 | length 66.8
  Top Layer w0.25: X7.1@52.8,48.6 52.8,49 54.95,51.15 56.45,51.15 J2.7@57.805,52.505 ; M1.196@63,65.6 63,66.75 62.85,66.9 61,66.9 60.4,67.5 60.4,68.8 60.65,69.05 64.05,69.05 v1(64.7,68.4)
  L1-Signal w0.15: X7.1@52.8,48.6 52.8,51.001 52.25,51.551 52.25,57.623 58.05,63.423 58.05,66.55 60.85,69.35 63.75,69.35 v1(64.7,68.4) 65.4,68.4 66.45,69.45 68.65,69.45 71.45,72.25 76.225,72.25 77.925,70.55 v1(78,70.55)
  Bottom Layer w0.25: U6.6@63.017,71.481 64.431,71.481 64.45,71.5 64.7,71.25 v1(64.7,68.4) ; U3.19@77.15,70.45 77.5,70.45 77.6,70.55 v1(78,70.55)
SPI_CS: J2.12 M1.202 X12.1 | length 37.7
  Top Layer w0.15: v1(61.45,62.85) 63.4,62.85 64.475,63.925 64.475,65.575 M1.202@64.5,65.6
  L4-Signal w0.15: X12.1@52.9,43.6 52.9,43.935 58.665,49.7 61.635,49.7 63.935,52 63.935,53.915 63.3,54.55 61.12,54.55 J2.12@60.345,53.775
  L1-Signal w0.15: J2.12@60.345,53.775 60.494,53.923 60.494,54.944 64.163,58.613 64.163,60.137 v1(61.45,62.85)
SPI_MISO: J2.11 M1.198 U3.24 U6.2 X4.1 | length 63.9
  Top Layer w0.25: X4.1@52.8,46.6 53.35,46.6 54.6,47.85 54.6,48.5 55.6,49.5 57.34,49.5 J2.11@60.345,52.505 ; v1(61.2,68.45) 62.05,68.45 63.5,67 M1.198@63.5,65.6
  L1-Signal w0.15: X4.1@52.8,46.6 54.1,47.9 54.1,50.55 52.85,51.8 52.85,57.374 58.65,63.174 58.65,65.9 v1(61.2,68.45) 61.99,68.45 63.54,66.9 76.85,66.9 v1(77.9,67.95)
  Bottom Layer w0.25: U6.2@57.556,70.211 59.439,70.211 v1(61.2,68.45) ; U3.24@77.15,67.95 v1(77.9,67.95)
SPI_MOSI: J2.9 M1.200 U3.21 U6.5 X5.1 | length 69.8
  Top Layer w0.25: X5.1@51,47.6 53.2,47.6 54,48.4 54,49.1 55.418,50.518 57.088,50.518 J2.9@59.075,52.505 ; M1.200@64,65.6 64,66.8 v1(64.75,67.55)
  L1-Signal w0.15: X5.1@51,47.6 53.037,47.6 53.7,48.263 53.7,50.526 52.55,51.676 52.55,57.499 58.35,63.299 58.35,66.426 60.924,69 63.3,69 v1(64.75,67.55) 65.608,67.55 65.783,67.375 68.117,67.375 68.5,67.758 68.5,68.067 71.883,71.45 76.076,71.45 77,70.526 77,70.164 77.77,69.393 v1(78.007,69.393)
  Bottom Layer w0.25: U6.5@63.017,72.751 64.599,72.751 65.85,71.5 65.85,68.65 v1(64.75,67.55) ; U3.21@77.15,69.45 77.95,69.45 v1(78.007,69.393)
TOP_5V: C255.1 C258.2 D31.2 J16.L1 J16.U1 U68.6 X83.1 | length 23
  Top Layer w0.75: v1(15.85,17.8) 18.481,17.8 18.7,17.581 C255.1@18.7,16.677 X83.1@18.7,13.6
  Bottom Layer w0.4: 20.752,11.548 25.15,11.548
  Bottom Layer w0.5: v1(16.5,17.8) 16.519,17.819 16.984,17.819 17.45,18.285 C258.2@17.45,18.7 18.621,18.7 18.661,18.74 U68.6@18.661,18.745 ; X83.1@18.7,13.6 20.752,11.548 ; J16.L1@26.75,10.069 26.644,10.175 25.825,10.175 25.15,10.85 25.15,11.548 25.15,12.2 26.08,13.13 26.611,13.13 J16.U1@26.75,13.269
  Bottom Layer w0.75: v1(15.85,17.8) v1(16.5,17.8)
UART_1_CTS: M1.135 U16.7 | length 20.9
  Top Layer w0.15: U16.7@43.5,43.225 44.525,43.225 44.625,43.325 47.782,43.325 48.307,43.85 v1(48.8,43.85) ; M1.135@45.75,57.4 45.75,46.65 v1(46.21,46.19)
  Bottom Layer w0.15: v1(46.21,46.19) 47.11,46.19 48.75,44.55 48.75,43.9 v1(48.8,43.85)
UART_1_CTS_3V: R246.2 RA2.6 U16.15 U55.3 | length 91.3
  Top Layer w0.15: RA2.6@38.2,37.95 v1(38.2,38.918) 38.2,42.65 39.175,43.625 U16.15@42.1,43.625 ; v1(92.25,46.5) 93.083,46.5 93.183,46.4 93.186,46.4 93.392,46.194 U55.3@96.37,46.194
  L2-Signal w0.15: v1(38.2,38.918) 38.2,43.55 39.05,44.4 43.533,44.4 43.608,44.325 44.292,44.325 44.367,44.4 47.142,44.4 47.292,44.55 49.3,44.55 51.8,42.05 62.976,42.05 64.258,43.332 89.58,43.332 90,43.752 90.491,43.752 90.707,43.968 91.322,43.968 92.16,44.806 92.16,45.607 92.248,45.695 92.25,45.695 v1(92.25,46.5)
  Bottom Layer w0.15: v1(92.25,46.5) 92.229,46.521 91.829,46.521 91.3,47.05 91.3,48.7 90.4,49.6 90.4,51.45 91.425,52.475 96.467,52.475 96.875,52.067 96.875,51.243 97.075,51.043 97.075,50.743 R246.2@97.5,50.318
UART_1_RTS: M1.133 RA1.7 U16.3 | length 26.8
  Top Layer w0.15: U16.3@43.5,41.625 44.825,41.625 46.75,39.7 v1(46.75,38.4) RA1.7@46.75,37.4 ; v1(45.2,45.45) 45.2,46.176 45.2,57.35 M1.133@45.25,57.4
  Bottom Layer w0.15: v1(45.2,45.45) 47.725,42.925 47.725,39.375 v1(46.75,38.4)
UART_1_RTS_3V: R245.2 U16.19 U55.2 | length 79.4
  Top Layer w0.15: v1(39.9,40.95) 40.986,42.036 42.089,42.036 U16.19@42.1,42.025 ; v1(92.15,47.3) 92.272,47.3 92.572,47.6 93.187,47.6 93.437,47.35 96.255,47.35 U55.2@96.37,47.464
  L2-Signal w0.15: v1(36.6,41.5) 36.6,42.75 38.55,44.7 43.658,44.7 43.733,44.625 44.167,44.625 44.242,44.7 47.017,44.7 47.167,44.85 49.45,44.85 51.95,42.35 62.826,42.35 64.126,43.65 88,43.65 88.525,44.175 88.525,46.824 89.821,48.12 91.33,48.12 v1(92.15,47.3)
  Bottom Layer w0.15: v1(36.6,41.5) 39.35,41.5 v1(39.9,40.95) ; v1(92.15,47.3) 92.65,47.8 96.05,47.8 96.368,48.118 R245.2@97.5,48.118
UART_1_RX_3V: R248.2 RA2.5 U16.16 U54.3 | length 84.3
  Top Layer w0.15: RA2.5@39,37.95 v1(39,38.9) 39,42.75 39.475,43.225 U16.16@42.1,43.225 ; v1(91.25,40.85) 92.277,39.823 93.937,39.823 94.508,40.394 U54.3@96.347,40.394
  L2-Signal w0.15: v1(39,38.9) 39,43 39.3,43.3 50.1,43.3 51.65,41.75 63.121,41.75 64.403,43.032 89.168,43.032 89.6,42.6 89.6,41.65 90.4,40.85 v1(91.25,40.85)
  Bottom Layer w0.15: v1(91.25,40.85) 91.229,40.871 90.829,40.871 90.262,41.438 90.262,43.662 90.568,43.968 95.283,43.968 95.665,44.35 97.075,44.35 97.5,43.925 R248.2@97.5,43.718
UART_1_RXD: M1.129 U16.6 | length 23.1
  Top Layer w0.15: U16.6@43.5,42.825 45.783,42.825 45.983,43.025 48.975,43.025 49.45,43.5 49.45,49.15 46.8,51.8 v1(46.8,54.15) ; v1(44.2,55.4) 44.25,55.4 M1.129@44.25,57.4
  Bottom Layer w0.15: v1(44.2,55.4) 45.55,55.4 v1(46.8,54.15)
UART_1_TX_3V: R247.2 U16.20 U54.2 | length 72.3
  Top Layer w0.15: v1(40.8,40.8) 40.853,40.853 40.853,41.325 41.02,41.491 41.02,41.494 41.151,41.625 U16.20@42.1,41.625 ; v1(88.7,41.85) 89.5,42.65 93.763,42.65 94.749,41.664 U54.2@96.347,41.664
  L2-Signal w0.15: v1(40.8,40.8) 40.853,40.853 40.853,41.325 41.045,41.517 41.045,41.52 41.152,41.626 41.826,41.626 43.2,43 49.971,43 51.521,41.45 63.245,41.45 64.509,42.714 87.836,42.714 v1(88.7,41.85)
  Bottom Layer w0.15: v1(88.7,41.85) 89.962,43.112 89.962,44.612 90.7,45.35 93.305,45.35 93.307,45.348 95.393,45.348 95.395,45.35 95.5,45.35 96.068,45.918 R247.2@97.5,45.918
UART_1_TXD: M1.131 RA1.8 U16.2 | length 27.2
  Top Layer w0.15: U16.2@43.65,41.225 44.675,41.225 45.95,39.95 v1(45.95,38.4) RA1.8@45.95,37.4 ; v1(43.95,45.15) 44.75,45.95 44.75,49.5 M1.131@44.75,57.4
  Bottom Layer w0.15: v1(43.95,45.15) 44.758,45.15 47.4,42.508 47.4,39.85 v1(45.95,38.4)
UART_2_RTS: M1.141 RA1.5 U16.5 | length 31
  Top Layer w0.15: U16.5@43.5,42.425 45.225,42.425 48.35,39.3 RA1.5@48.35,37.4 49.15,37.4 50.7,38.95 50.7,41.55 50.1,42.15 50.1,50.258 50.025,50.333 50.025,50.767 50.1,50.842 50.1,52.3 47.25,55.15 M1.141@47.25,57.4
UART_2_RTS_3V: R242.2 U16.17 U51.2 | length 69.1
  Top Layer w0.15: v1(39.85,42.65) 39.92,42.72 40.375,42.72 40.48,42.825 U16.17@42.1,42.825 ; v1(92,34.7) 93.75,34.7 94.348,35.298 U51.2@96.191,35.298
  L2-Signal w0.15: v1(46.3,42.475) 46.422,42.475 46.611,42.286 48.944,42.286 49.083,42.425 49.675,42.425 52.05,40.05 65.649,40.05 67.449,38.25 78.349,38.25 82.549,34.05 91.35,34.05 v1(92,34.7)
  Bottom Layer w0.15: v1(39.85,42.65) 39.892,42.65 40.242,43 45.9,43 46.044,42.856 46.044,42.852 46.3,42.597 v1(46.3,42.475) ; v1(92,34.7) 95.95,34.7 96.75,33.9 R242.2@97.5,33.9
UART_2_RX_3V: R185.2 R186.2 RA2.7 U16.14 | length 72.7
  Top Layer w0.15: U16.14@41.95,44.025 38.675,44.025 37.4,42.75 RA2.7@37.4,37.95 37.4,37.35 37.55,37.2 44.8,37.2 45.35,36.65 48.95,36.65 51.75,39.45 52.678,39.45 52.978,39.15 v1(53.1,39.15) ; R185.2@90.95,28.15 R186.2@91.95,28.15
  Top Layer w0.25: R185.2@90.95,28.15 v1(90.95,28.887)
  L2-Signal w0.15: v1(53.1,39.15) 53.4,39.45 65.4,39.45 67.2,37.65 78.1,37.65 82.3,33.45 87.8,33.45 89.35,31.9 89.35,30.393 90.856,28.887 v1(90.95,28.887)
UART_2_RXD: M1.137 U16.8 | length 19.8
  Top Layer w0.15: U16.8@43.5,43.625 45.779,43.625 46.004,43.85 47.883,43.85 49.15,45.117 49.15,48.6 46.25,51.5 M1.137@46.25,57.4
UART_2_TX_3V: R189.2 U16.18 U50.2 | length 74.4
  Top Layer w0.15: v1(39.9,41.8) 39.938,41.8 40.343,42.205 40.605,42.205 40.825,42.425 U16.18@42.1,42.425 ; v1(90,31.25) 91.728,29.522 U50.2@96.191,29.522
  L2-Signal w0.15: v1(46.875,41.7) 48.348,41.7 48.499,41.851 49.825,41.851 51.926,39.75 65.524,39.75 67.324,37.95 78.224,37.95 82.424,33.75 88.4,33.75 90,32.15 v1(90,31.25)
  Bottom Layer w0.15: v1(39.9,41.8) 39.938,41.8 40.343,42.205 45.745,42.205 46.275,41.675 46.85,41.675 v1(46.875,41.7) ; v1(90,31.25) 89.55,30.8 89.55,30 90.05,29.5 R189.2@97.5,29.5
UART_2_TXD: M1.139 RA1.6 U16.4 | length 29.1
  Top Layer w0.15: U16.4@43.5,42.025 45.025,42.025 47.55,39.5 47.55,38.45 v1(47.5,38.4) 47.5,37.45 RA1.6@47.55,37.4 ; M1.139@46.75,57.4 46.75,55.05 49.8,52 49.8,50.967 49.725,50.892 49.725,50.208 49.8,50.133 49.8,41.65 49.25,41.1 v1(48.35,41.1)
  Bottom Layer w0.15: v1(47.5,38.4) 47.6,38.4 48.15,38.95 48.15,40.787 48.35,40.987 v1(48.35,41.1)
UART_3_RXD: J17.2 M1.147 Q15.1 R264.2 | length 72.8
  Top Layer w0.15: v1(49.15,58.65) 49.7,59.2 50.45,59.2 50.75,58.9 50.75,58.892 50.775,58.867 50.775,57.425 M1.147@50.75,57.4
  L3-Signal w0.15: v1(26.9,76.7) 26.9,75.85 27.2,75.55 32.25,75.55 v1(49.15,58.65)
  Bottom Layer w0.15: J17.2@19.1,54.9 19.1,56.05 20.5,57.45 47.95,57.45 v1(49.15,58.65) ; v1(26.9,76.7) 27.8,77.6 29.9,77.6 30.2,77.3 R264.2@30.2,76.65 31.775,76.65 Q15.1@32.375,76.05
UART_3_RXD_3V: J1.4 Q15.6 R271.2 | length 35.9
  Top Layer w0.15: J1.4@19.21,103.05 19.21,101.89 19.53,101.57 19.53,94.52 20.45,93.6 20.45,89.85 26.5,83.8 v1(26.5,77.6)
  Bottom Layer w0.15: v1(26.5,77.6) 26.3,77.4 26.3,75.671 26.95,75.021 27.367,75.021 27.389,75 28.75,75 R271.2@29.4,75.65 29.95,75.65 30.35,76.05 Q15.6@31.025,76.05
UART_3_TXD: J17.3 M1.149 Q15.4 R269.2 | length 74.1
  Top Layer w0.15: M1.149@51.25,57.4 51.275,57.425 51.275,58.825 v1(51.3,58.85)
  L3-Signal w0.15: v1(27.15,74.496) 27.173,74.473 27.5,74.8 30.85,74.8 48.35,57.3 50.526,57.3 51.3,58.074 v1(51.3,58.85)
  Bottom Layer w0.15: J17.3@21.64,54.9 21.64,56.04 22.05,56.45 27.603,56.45 28.103,56.95 28.228,57.075 34.16,57.075 35.34,57.075 49.525,57.075 v1(51.3,58.85) ; v1(27.15,74.496) 27.15,74.45 29.8,74.45 30.4,75.05 Q15.4@31.025,75.05 31.35,75.05 31.85,74.55 32.85,74.55 33,74.4 33.85,74.4 34.05,74.6 R269.2@34.5,74.6
UART_3_TXD_3V: J1.5 Q15.3 R270.2 | length 45.7
  Top Layer w0.15: J1.5@16.67,103.05 16.67,101.78 16.99,101.46 16.99,92.61 25.8,83.8 25.8,73.971 v1(25.821,73.971)
  L3-Signal w0.15: v1(33.75,75.05) 34.95,73.85 v1(35.05,73.85)
  Bottom Layer w0.15: v1(25.821,73.971) 28.629,73.971 R270.2@29.2,73.4 34.6,73.4 v1(35.05,73.85) ; Q15.3@32.375,75.05 v1(33.75,75.05)