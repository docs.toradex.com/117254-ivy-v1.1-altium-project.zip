# Altium PCB 46806005.~(3).PcbDoc (part 5 of 9)
Units mm, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 130 x 105 mm, 8 copper layers (Top Layer, P1-GND, L1-Signal, L2-Signal, L3-Signal, L4-Signal, P2-GND, Bottom Layer), stack 1.63 mm thick; 795 components, 496 nets, 2816 pads, 1210 vias.
Unrouted connection lines stored in the file: 1.

## Via types
v1: diameter 0.6, hole 0.3, Top Layer to Bottom Layer, tented both sides, 1145 vias
v2: diameter 0.6, hole 0.3, Top Layer to Bottom Layer, 65 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
DSI_1_D3_N: L39.2 M1.23 | length 21.9
  Top Layer w0.2: v1(17.65,59.5) 17.65,59.392 17.85,59.192 17.85,58.795 17.825,58.77 17.825,58.424 17.8,58.399 17.8,57.45 M1.23@17.75,57.4 ; v1(22.05,70.55) 22.127,70.627 22.127,70.842 22.413,71.129 22.413,71.922 22.3,72.036 22.3,72.425 L39.2@22.35,72.475
  L1-Signal w0.15: v1(17.65,59.5) 17.65,59.622 17.825,59.797 17.825,59.945 17.825,60.02 ccw(c17.585,60.02) 17.585,60.26 17.439,60.26 cw(c17.439,60.5) 17.199,60.5 cw(c17.439,60.5) 17.439,60.74 17.585,60.74 ccw(c17.585,60.98) 17.825,60.98 17.825,61.33 17.825,61.605 ccw(c17.521,61.605) 17.521,61.908 17.192,61.908 cw(c17.192,62.612) 17.192,63.315 17.521,63.315 ccw(c17.521,63.619) 17.825,63.619 17.825,64.415 17.825,68.691 18.984,69.85 22.162,69.85 22.25,69.938 22.25,70.237 22.05,70.437 v1(22.05,70.55)
DSI_1_D3_P: L39.1 M1.25 | length 22.3
  Top Layer w0.2: M1.25@18.25,57.4 18.2,57.45 18.2,58.399 18.175,58.424 18.175,58.625 18.2,58.65 18.2,59.192 18.4,59.392 v1(18.4,59.5) ; v1(21.52,71.08) 21.596,71.157 21.603,71.15 21.939,71.15 22.063,71.274 22.063,71.778 21.95,71.891 21.95,72.126 21.9,72.176 21.9,72.425 L39.1@21.85,72.475
  L1-Signal w0.15: v1(18.4,59.5) 18.4,59.622 18.225,59.797 18.225,61.33 18.225,61.605 ccw(c17.521,61.605) 17.521,62.308 17.192,62.308 cw(c17.192,62.612) 17.192,62.915 17.521,62.915 ccw(c17.521,63.619) 18.225,63.619 18.225,64.415 18.225,68.525 19.15,69.45 22.328,69.45 22.65,69.772 22.65,70.8 22.366,71.084 v1@21.524,71.084
DSI_BKL_EN: J15.17 M1.21 R199.2 | length 41.7
  Top Layer w0.15: J15.17@6.981,83.478 8.422,83.478 R199.2@8.45,83.45 9.05,82.85 10.744,82.85 11.094,83.2 v1(17.2,83.2) ; v1(11.423,66.253) 11.35,66.18 11.35,64.5 12.4,63.45 13.1,63.45 16.1,60.45 16.1,59.748 17.25,58.598 M1.21@17.25,57.4
  L1-Signal w0.15: v1(11.423,66.253) 11.423,73.063 17.2,78.84 v1(17.2,83.2)
DSI_INT: J15.19 M1.17 R200.1 | length 41.7
  Top Layer w0.15: J15.19@6.981,84.478 8.049,84.478 8.227,84.3 15.511,84.3 15.786,84.025 v1(15.908,84.025) ; v1(10.233,65.34) 10.233,64.768 12.151,62.85 12.851,62.85 15.5,60.201 15.5,59.499 16.25,58.749 M1.17@16.25,57.4
  L1-Signal w0.15: v1(10.233,65.34) 10.233,72.833 15.908,78.508 v1(15.908,84.025)
  Bottom Layer w0.15: R200.1@15.9,84.75 15.908,84.742 v1(15.908,84.025)
DSI_SCL: J15.20 M1.55 R207.1 | length 61.3
  Top Layer w0.15: J15.20@4.081,84.978 7.973,84.978 8.351,84.6 11.324,84.6 12.774,86.05 16.072,86.05 v1(16.822,86.8) ; v1(25.5,55.3) 25.75,55.55 M1.55@25.75,57.4
  L1-Signal w0.15: v1(16.822,86.8) 16.754,86.867 16.754,87.175 16.297,87.632 16.297,88.067 16.59,88.36 16.635,88.36 16.65,88.375 17.039,88.375 18.625,86.789 20.278,86.789 29.45,77.617 29.45,67.923 28.3,66.773 28.3,63.624 29.1,62.824 29.1,58 26.4,55.3 v1(25.5,55.3)
  Bottom Layer w0.25: R207.1@15.9,86.8 v1(16.822,86.8)
DSI_SDA: J15.21 M1.53 R208.1 | length 56.7
  Top Layer w0.15: J15.21@6.981,85.478 7.898,85.478 8.098,85.278 8.476,84.9 11.2,84.9 11.578,85.278 12.65,86.35 15.75,86.35 16.2,86.8 16.2,87.228 v1(16.822,87.85) ; v1(24.6,55.55) 25.25,56.2 M1.53@25.25,57.4
  L1-Signal w0.15: v1(16.822,87.85) 18.183,86.489 20.154,86.489 29.15,77.492 29.15,68.047 28,66.897 28,63.5 28.8,62.7 28.8,58.124 26.581,55.905 24.955,55.905 v1(24.6,55.55)
  Bottom Layer w0.25: R208.1@15.9,87.85 v1(16.822,87.85)
DVDD12: C17.2 C18.2 C19.2 C20.1 C24.2 C25.2 C27.1 C29.2 C31.2 C32.2 C34.1 C35.2 C37.2 C38.2 C41.1 C42.2 C45.2 C48.1 C66.2 L7.1 R23.1 R24.2 U8.1 U8.3 U8.7 U8.13 U8.27 U8.37 U8.43 U8.49 U9.6 X14.1 | length 40.2
  Top Layer w0.25: C25.2@28.1,23.35 C25.2@28.106,23.344 ; C19.2@28.106,21.874 C19.2@28.109,21.877 ; v1@28.106,22.6 v1@28.109,22.597 ; v1@28.106,22.612 v1(28.111,22.606) 28.178,22.673 28.573,22.673 28.775,22.875 28.775,23.225 C29.2@28.9,23.35 ; C37.2@28.9,28.1 29.025,28.225 29.025,28.625 29.273,28.873 v1@29.696,28.873 ; C31.2@29.7,28.1 29.706,28.106 v1@29.706,28.883 ; v1@29.739,28.861 30.139,28.861 30.375,28.625 30.375,28.225 C34.1@30.5,28.1 ; C35.2@30.5,23.35 C35.2@30.511,23.339 ; v1(30.511,22.606) 30.578,22.673 30.973,22.673 31.175,22.875 31.175,23.225 C32.2@31.3,23.35 ; C27.1@31.35,28.1 31.475,28.225 31.475,28.515 31.782,28.822 32.044,28.822 v1(32.111,28.889) v1@32.131,28.869 ; R23.1@31.443,32.307 R23.1@31.45,32.3 ; R24.2@31.443,33.65 R24.2@31.465,33.672 ; C41.1@32.15,28.1 32.131,28.119 v1@32.131,28.869 ; C42.2@32.2,23.35 32.325,23.225 32.325,22.925 32.577,22.673 32.844,22.673 v1(32.911,22.606) v1@32.956,22.65 ; C24.2@32.95,28.1 32.825,28.225 32.825,28.562 32.59,28.797 32.59,28.822 32.178,28.822 v1@32.131,28.869 ; C20.1@34.477,25.775 34.427,25.775 34.068,25.417 33.767,25.417 v1(33.7,25.35) 33.7,26.25 33.9,26.45 34.352,26.45 C18.2@34.477,26.575
  Top Layer w0.5: v1(27.3,30.6) C48.1@27.3,31.35 ; v1@28.106,22.612 C25.2@28.106,23.344 ; C19.2@28.109,21.877 v1@28.109,22.597 ; v1(28.35,30.6) C45.2@28.35,31.35 ; C17.2@30.511,21.85 v1(30.511,22.606) C35.2@30.511,23.339 ; R23.1@31.443,32.307 R24.2@31.443,33.65 ; R24.2@31.465,33.672 C66.2@31.465,34.95 ; v1@32.956,22.65 32.956,23.306 C38.2@33,23.35
  Top Layer w0.75: v1(27.3,30.6) v1(28.35,30.6) 29.711,30.6 ; v1(29.711,28.889) 29.711,30.6 ; L7.1@30.033,34.95 X14.1@30.033,33.51 30.033,31.633 29.711,31.311 29.711,30.6 ; L7.1@30.033,34.95 C66.2@31.465,34.95 U9.6@31.465,37.05
  Bottom Layer w0.15: v1(27.3,30.6) v1@27.306,30.594 ; U8.1@27.306,29.7 U8.1@27.311,29.695 ; 28.111,30.24 28.35,30.478 v1(28.35,30.6) ; v1(33.7,25.35) v1@33.703,25.347
  Bottom Layer w0.2: U8.1@27.306,29.7 v1@27.306,30.594 ; U8.49@28.111,21.8 v1(28.111,22.606) ; U8.3@28.111,29.695 28.111,30.24 ; v1(29.711,28.889) U8.7@29.711,29.695 ; U8.43@30.511,21.8 v1(30.511,22.606) ; v1(32.111,28.889) U8.13@32.111,29.695 ; U8.37@32.911,21.8 v1(32.911,22.606) ; v1@33.703,25.347 U8.27@34.459,25.347
ETH1_ACT: M1.237 R2.2 | length 79.9
  Top Layer w0.15: v1(73.2,58.9) 73.25,58.85 M1.237@73.25,57.4
  L1-Signal w0.15: v1(64.55,4.85) 63.213,4.85 60.456,7.607 60.456,7.844 59.225,9.075 59.225,18.53 59.29,18.595 59.29,20.49 59.8,21 59.8,29.177 65.575,34.952 65.575,37.302 71.65,43.377 71.65,51.326 73.2,52.876 v1(73.2,58.9)
  Bottom Layer w0.15: v1(64.55,4.85) 76.773,4.85 77.123,4.5 R2.2@79.95,4.5
ETH1_D0_N: J10.8 M1.227 U1.2 U1.9 | length 63
  Top Layer w0.18: M1.227@70.75,57.4 70.69,57.46 70.69,58.367 70.665,58.392 70.665,59.898 72.687,61.92 74.83,61.92 75.3,61.45 75.3,60.723 75.31,60.713 75.31,60.165 75.1,59.955 v1(75.1,59.85)
  Bottom Layer w0.18: J10.8@72.35,13.569 72.373,13.592 72.373,15.011 72.17,15.213 72.17,16.92 72.95,17.7 74.755,17.7 76.748,19.693 76.748,20.454 76.748,20.956 76.663,21.041 U1.2@76.663,21.228 76.663,21.416 76.727,21.48 76.748,21.48 76.748,21.811 76.727,21.811 76.663,21.875 U1.9@76.663,22.062 76.663,22.25 76.748,22.335 76.748,23.048 79.52,25.82 79.52,36.863 78.65,37.733 78.65,41.483 75.335,44.798 75.335,55.608 75.335,55.698 ccw(c75.08,55.698) 75.08,55.954 75.07,55.954 cw(c75.07,56.209) 75.07,56.464 75.08,56.464 ccw(c75.08,56.719) 75.335,56.719 75.335,57.09 75.335,59.062 75.31,59.087 75.31,59.535 75.1,59.745 v1(75.1,59.85)
ETH1_D0_P: J10.9 M1.225 U1.1 U1.10 | length 63.1
  Top Layer w0.18: M1.225@70.25,57.4 70.31,57.46 70.31,58.367 70.335,58.392 70.335,60.035 72.55,62.25 74.967,62.25 75.63,61.587 75.63,60.86 75.64,60.85 75.64,60.165 75.85,59.955 v1(75.85,59.85)
  Bottom Layer w0.18: J10.9@73.62,16.109 72.755,15.244 72.606,15.244 72.5,15.35 72.5,16.783 73.087,17.37 74.892,17.37 77.078,19.556 77.078,20.318 77.078,20.956 77.163,21.041 U1.1@77.163,21.228 77.163,21.416 77.099,21.48 77.078,21.48 77.078,21.811 77.099,21.811 77.163,21.875 U1.10@77.163,22.062 77.163,22.25 77.078,22.335 77.078,22.911 79.85,25.683 79.85,37 78.98,37.87 78.98,41.62 75.665,44.935 75.665,59.199 75.64,59.224 75.64,59.535 75.85,59.745 v1(75.85,59.85)
ETH1_D1_N: J10.6 M1.231 U1.5 U1.6 | length 60.2
  Top Layer w0.18: M1.231@71.75,57.4 71.81,57.46 71.81,58.367 71.835,58.392 71.835,60.052 72.413,60.63 73.53,60.63 73.739,60.839 73.714,60.863 73.714,61.013 v1(73.634,61.093)
  Bottom Layer w0.18: J10.6@69.81,13.569 69.853,13.612 69.853,15.031 69.62,15.263 69.62,17.037 70.283,17.7 71.6,17.7 72.61,18.71 73.545,18.71 75.248,20.412 75.248,20.956 75.163,21.041 U1.5@75.163,21.228 75.163,21.416 75.226,21.48 75.248,21.48 75.248,21.811 75.226,21.811 75.163,21.875 U1.6@75.163,22.062 75.163,22.25 75.248,22.335 75.248,22.848 78.67,26.27 78.67,36.263 77.8,37.133 77.8,40.833 73.844,44.79 73.844,60.777 73.634,60.987 v1(73.634,61.093)
ETH1_D1_P: J10.7 M1.233 U1.4 U1.7 | length 60
  Top Layer w0.18: M1.233@72.25,57.4 72.19,57.46 72.19,58.367 72.165,58.392 72.165,59.915 72.55,60.3 73.667,60.3 74.384,61.017 v1(74.384,61.093)
  Bottom Layer w0.18: J10.7@71.08,16.109 70.235,15.264 70.086,15.264 69.95,15.4 69.95,16.9 70.42,17.37 71.737,17.37 72.747,18.38 73.682,18.38 75.578,20.276 75.578,20.956 75.663,21.041 U1.4@75.663,21.228 75.663,21.416 75.599,21.48 75.578,21.48 75.578,21.811 75.599,21.811 75.663,21.875 U1.7@75.663,22.062 75.663,22.25 75.578,22.335 75.578,22.711 79,26.133 79,36.4 78.13,37.27 78.13,40.97 74.174,44.926 74.174,54.374 74.35,54.55 74.35,54.729 74.174,54.905 74.174,60.777 74.384,60.987 v1(74.384,61.093)
ETH1_D2_N: J10.4 M1.241 U2.2 U2.9 | length 56.5
  Top Layer w0.18: v1(71.25,55.05) 71.355,55.05 71.565,55.26 73.525,55.26 74.165,55.9 74.165,56.408 74.19,56.433 74.19,57.34 M1.241@74.25,57.4
  Bottom Layer w0.18: J10.4@67.27,13.569 67.412,13.711 67.412,15.021 67.12,15.313 67.12,17.02 68.05,17.95 68.783,17.95 69.483,18.65 71.235,18.65 72.535,19.95 72.535,20.658 72.535,20.968 72.45,21.053 U2.2@72.45,21.241 72.45,21.428 72.514,21.492 72.535,21.492 72.535,21.823 72.514,21.823 72.45,21.887 U2.9@72.45,22.075 72.45,22.262 72.535,22.347 72.535,22.985 73.45,23.9 75,23.9 77.82,26.72 77.82,35.913 76.97,36.763 76.97,40.313 72.35,44.933 72.35,54.5 71.82,55.03 71.27,55.03 v1(71.25,55.05)
ETH1_D2_P: J10.5 M1.239 U2.1 U2.10 | length 56.3
  Top Layer w0.18: v1(71.25,55.8) 71.355,55.8 71.565,55.59 73.388,55.59 73.835,56.037 73.835,56.408 73.81,56.433 73.81,57.34 M1.239@73.75,57.4
  Bottom Layer w0.18: J10.5@68.54,16.109 68.54,16 67.795,15.255 67.645,15.255 67.45,15.45 67.45,16.883 68.187,17.62 68.92,17.62 69.62,18.32 71.372,18.32 72.865,19.813 72.865,20.522 72.865,20.968 72.95,21.053 U2.1@72.95,21.241 72.95,21.428 72.886,21.492 72.865,21.492 72.865,21.823 72.886,21.823 72.95,21.887 U2.10@72.95,22.075 72.95,22.262 72.865,22.347 72.865,22.848 73.587,23.57 75.137,23.57 78.15,26.583 78.15,36.05 77.3,36.9 77.3,40.45 72.68,45.07 72.68,53.408 72.893,53.622 72.893,53.771 72.68,53.984 72.68,54.637 71.87,55.446 71.703,55.446 71.349,55.8 v1(71.25,55.8)
ETH1_D3_N: J10.2 M1.245 U2.5 U2.6 | length 58.4
  Top Layer w0.18: v1(70.6,53.4) 70.6,53.505 70.81,53.715 70.81,54.107 71.109,54.405 73.589,54.405 75.335,56.152 75.335,56.408 75.31,56.433 75.31,57.34 M1.245@75.25,57.4
  Bottom Layer w0.18: J10.2@64.73,13.569 64.813,13.652 64.813,15.071 64.57,15.313 64.57,16.887 65.333,17.65 66.233,17.65 67.613,19.03 68.213,19.03 68.863,19.68 70.565,19.68 71.035,20.15 71.035,20.968 70.95,21.053 U2.5@70.95,21.241 70.95,21.428 71.014,21.492 71.035,21.492 71.035,21.823 71.014,21.823 70.95,21.887 U2.6@70.95,22.075 70.95,22.262 70.985,22.297 71.057,22.297 71.057,22.387 ; v1(70.6,53.4) 70.6,53.355 70.87,53.085 70.87,44.963 76.07,39.763 76.07,36.513 76.97,35.613 76.97,27.187 74.683,24.9 72.761,24.9 71.057,23.196 71.057,22.387
ETH1_D3_P: J10.3 M1.247 U2.4 U2.7 | length 58.4
  Top Layer w0.18: v1(71.35,53.4) 71.35,53.505 71.14,53.715 71.14,53.97 71.245,54.075 73.725,54.075 75.665,56.015 75.665,56.408 75.69,56.433 75.69,57.34 M1.247@75.75,57.4
  Bottom Layer w0.18: J10.3@66,16.109 65.195,15.304 65.046,15.304 64.9,15.45 64.9,16.75 65.47,17.32 66.37,17.32 67.75,18.7 68.35,18.7 69,19.35 70.702,19.35 71.365,20.013 71.365,20.968 71.45,21.053 U2.4@71.45,21.241 71.45,21.428 71.386,21.492 71.365,21.492 71.365,21.823 71.386,21.823 71.45,21.887 U2.7@71.45,22.075 71.45,22.262 71.415,22.297 U2.7@71.388,22.297 ; v1(71.35,53.4) 71.35,53.286 71.2,53.136 71.2,52.657 71.2,52.133 ccw(c71.455,52.133) 71.455,51.878 71.48,51.878 cw(c71.48,51.623) 71.48,51.368 71.455,51.368 ccw(c71.455,51.113) 71.2,51.113 71.2,50.513 71.2,45.1 76.4,39.9 76.4,36.65 77.3,35.75 77.3,27.05 74.82,24.57 72.898,24.57 71.387,23.06 U2.7@71.387,22.298
ETH1_LINK: M1.235 R1.2 | length 91.6
  Top Layer w0.15: M1.235@72.75,57.4 72.75,58.608 72.675,58.683 72.675,59.117 72.733,59.175 72.733,59.483 v1(72.8,59.55)
  L1-Signal w0.15: v1(59.931,7.519) 58.925,8.525 58.925,18.654 58.99,18.719 58.99,20.614 59.49,21.114 59.49,29.291 65.275,35.076 65.275,37.426 71.35,43.501 71.35,51.45 72.5,52.6 72.5,59.128 72.8,59.428 v1(72.8,59.55)
  Bottom Layer w0.15: v1(59.931,7.519) 61.3,6.15 61.3,2.672 62.672,1.3 81.95,1.3 83.1,2.45 83.1,4.1 82.7,4.5 R1.2@82,4.5
ETH2_ACT: Q14.5 R267.2 R268.1 U26.47 | length 9.8
  Bottom Layer w0.15: U26.47@51.4,21.825 52.325,21.825 52.7,21.45 R267.2@52.7,19.672 R268.1@52.7,18.6 52.7,17.95 52.9,17.75 53.9,17.75 54.85,16.8 56.284,16.8 56.5,16.584 Q14.5@56.5,16.125
ETH2_D0_N: J7.8 U26.2 U28.4 U28.7 | length 8.3
  Bottom Layer w0.15: U26.2@50.25,20.675 50.25,20.471 50.3,20.421 U28.4@50.3,19.317 U28.7@50.3,18.483 50.3,18.038 50.994,17.343 51.307,17.343 51.912,16.738 51.912,15.438 52.5,14.85 52.5,14.332 52.11,13.942 J7.8@52.11,13.619
ETH2_D0_P: J7.9 U26.1 U28.5 U28.6 | length 8.2
  Bottom Layer w0.15: U26.1@50.75,20.675 50.75,19.367 U28.5@50.8,19.317 U28.6@50.8,18.483 50.8,17.962 51.119,17.643 51.431,17.643 52.212,16.862 52.212,15.562 52.786,14.989 52.91,14.989 53.243,15.322 53.243,16.022 J7.9@53.38,16.159
ETH2_D1_N: J7.6 U26.5 U28.1 U28.10 | length 7.6
  Bottom Layer w0.15: U26.5@48.75,20.675 48.75,20.471 48.8,20.421 U28.1@48.8,19.317 U28.10@48.8,18.483 48.825,18.458 48.825,17.266 49.35,16.741 49.35,15.388 49.844,14.894 49.844,14.332 49.809,14.297 49.809,13.858 J7.6@49.57,13.619
ETH2_D1_P: J7.7 U26.4 U28.2 U28.9 | length 7.6
  Bottom Layer w0.15: U26.4@49.25,20.675 49.25,19.367 U28.2@49.3,19.317 U28.9@49.3,18.483 49.3,18.296 49.25,18.246 49.238,18.246 49.15,18.158 49.15,18.114 49.125,18.089 49.125,17.391 49.65,16.866 49.65,15.512 50.119,15.043 50.243,15.043 50.601,15.401 50.601,15.92 J7.7@50.84,16.159
ETH2_D2_N: J7.4 U26.8 U27.4 U27.7 | length 7.6
  Bottom Layer w0.15: J7.4@47.03,13.619 47.03,13.868 47.494,14.332 47.494,14.744 46.975,15.263 46.975,17.199 47.225,17.449 47.225,18.458 U27.7@47.2,18.483 U27.4@47.2,19.317 47.233,19.35 47.233,20.658 U26.8@47.25,20.675
ETH2_D2_P: J7.5 U26.7 U27.5 U27.6 | length 7.6
  Bottom Layer w0.15: U26.7@47.75,20.675 47.75,20.471 47.7,20.421 U27.6@47.7,18.483 47.7,17.5 47.275,17.075 47.275,15.387 47.688,14.974 47.812,14.974 47.9,15.062 47.9,15.421 48.3,15.821 J7.5@48.3,16.159
ETH2_D3_N: J7.2 U26.11 U27.1 U27.10 | length 8.1
  Bottom Layer w0.15: J7.2@44.49,13.619 44.7,13.829 44.7,14.762 44.612,14.85 44.526,14.85 44.35,15.026 44.35,16.85 45.15,17.65 45.4,17.65 45.7,17.95 U27.10@45.7,18.483 U27.1@45.7,19.317 45.75,19.367 U26.11@45.75,20.675
ETH2_D3_P: J7.3 U26.10 U27.2 U27.9 | length 7.9
  Bottom Layer w0.15: J7.3@45.76,16.159 45.76,15.86 45.05,15.15 44.738,15.15 44.65,15.238 44.65,16.726 45.274,17.35 45.524,17.35 45.681,17.507 46.05,17.876 46.05,18.158 46.138,18.246 46.15,18.246 46.2,18.296 U27.9@46.2,18.389 ; U27.9@46.2,18.483 U27.2@46.2,19.317 46.25,19.367 U26.10@46.25,20.675
ETH2_LINK: Q14.2 R265.2 R266.1 U26.45 | length 9.2
  Bottom Layer w0.15: U26.45@51.4,22.825 52.325,22.825 53.5,21.65 53.5,19.9 53.65,19.75 R266.1@53.65,18.6 54.175,18.075 56.266,18.075 56.5,17.841 Q14.2@56.5,17.475
FAULTn: R217.1 U68.4 | length 1.6
  Bottom Layer w0.15: U68.4@20.561,18.745 22.145,18.745 R217.1@22.15,18.75
GND: C2.1 C3.2 C4.1 C5.1 C6.1 C7.1 C8.1 C9.1 C10.1 C11.1 C12.1 C13.1 C14.1 C15.1 C16.1 C17.1 C18.1 C19.1 C20.2 C21.1 C22.1 C23.1 C24.1 C25.1 C26.1 C27.2 C28.1 C29.1 C30.1 C31.1 C32.1 C33.1 C34.2 C35.1 C36.1 C37.1 C38.1 C39.1 C40.1 C41.2 C42.1 C43.1 C44.1 C45.1 C46.1 C47.1 C48.2 C49.2 C50.1 C51.1 C52.1 C53.1 C54.2 C55.2 C56.1 C57.1 C58.1 C59.2 C60.2 C61.1 C62.1 C63.1 C64.1 C65.1 C66.1 C67.2 C68.2 C69.2 C70.1 C71.1 C72.1 C73.1 C74.1 C75.1 C76.1 C77.1 C78.1 C79.1 C81.2 C84.2 C86.1 C88.1 C89.1 C91.1 C92.1 C94.1 C95.1 C96.1 C97.2 C98.1 C99.1 C100.2 C101.2 C102.1 C103.2 C104.1 C106.1 C107.1 C108.1 C109.1 C111.1 C114.1 C115.1 C116.1 C117.2 C118.2 C119.2 C120.2 C133.1 C134.1 C135.1 C136.1 C137.1 C138.1 C139.1 C140.1 C141.1 C142.1 C143.1 C144.1 C145.1 C146.1 C147.1 C148.1 C149.1 C150.1 C151.1 C152.1 C153.1 C154.1 C155.1 C156.1 C157.1 C158.1 C159.1 C160.1 C161.1 C162.1 C163.1 C164.1 C165.1 C166.1 C167.1 C168.2 C169.2 C170.1 C171.1 C172.1 C173.1 C174.1 C175.1 C176.1 C177.1 C178.1 C179.1 C180.1 C181.1 C182.1 C207.1 C208.1 C209.1 C210.2 C211.2 C212.1 C213.1 C214.1 C215.1 C216.1 C217.1 C218.2 C219.2 C220.2 C226.1 C227.2 C228.2 C229.2 C239.1 C240.1 C241.1 C242.1 C243.1 C244.1 C245.1 C246.1 C247.1 C248.1 C249.1 C250.1 C251.1 C252.1 C253.1 C255.2 C257.1 C258.1 D3.1 D3.2 D4.2 D6.2 D18.2 D23.2 D26.2 D31.1 D32.2 D33.1 D34.1 J1.1 J2.1 J2.2 J4.A1/B12 J4.B1/A12 J5.15 J5.16 J7.1 J8.4 J8.9 J8.15 J8.18 J8.21 J8.26 J8.27 J8.29 J8.34 J8.35 J8.37 J8.40 J8.43 J8.50 J9.C5 J10.1 J12.6 J12.10 J12.11 J12.12 J12.13 J13.3 J13.5 J15.1 J15.4 J15.7 J15.10 J15.13 J15.16 J15.30 J15.SH1 J15.SH2 J15.SH3 J15.SH4 J16.L4 J16.L7 J16.U4 J16.U7 J17.1 L12.3 M1.10 M1.11 M1.18 M1.27 M1.28 M1.33 M1.39 M1.40 M1.45 M1.50 M1.51 M1.65 M1.68 M1.71 M1.77 M1.83 M1.86 M1.89 M1.97 M1.98 M1.103 M1.109 M1.110 M1.115 M1.121 M1.122 M1.127 M1.134 M1.145 M1.146 M1.158 M1.167 M1.170 M1.173 M1.179 M1.182 M1.194 M1.195 M1.204 M1.209 M1.223 M1.224 M1.229 M1.230 M1.236 M1.242 M1.243 Q1.1 Q1.4 Q2.1 Q2.4 Q3.1 Q3.4 Q4.1 Q4.4 Q5.2 Q6.2 Q7.2 Q8.2 Q11.1 Q11.4 Q13.2 Q14.1 Q14.4 R3.2 R7.1 R20.2 R21.2 R26.1 R27.1 R29.2 R31.2 R32.1 R33.1 R34.1 R38.1 R40.1 R46.1 R49.1 R52.1 R54.1 R55.2 R57.1 R60.1 R62.1 R63.1 R66.2 R67.1 R70.1 R71.1 R74.1 R75.1 R78.1 R79.1 R81.1 R82.1 R84.1 R88.1 R89.1 R106.1 R107.1 R108.1 R109.1 R114.1 R116.1 R118.1 R122.2 R128.2 R130.2 R131.2 R150.1 R156.2 R176.1 R178.1 R185.1 R188.1 R192.1 R197.1 R198.1 R199.1 R202.1 R205.1 R206.1 R212.1 R214.2 R216.1 R236.1 R240.1 R244.2 R250.2 R256.1 R262.1 R263.1 R266.2 R268.2 R272.2 R273.1 S1.3 S2.3 U1.3 U1.8 U2.3 U2.8 U3.2 U3.9 U3.16 U3.23 U3.32 U3.33 U5.4 U5.7 U6.4 U7.4 U7.9 U8.40 U8.69 U9.8 U9.9 U10.3 U10.5 U11.7 U11.9 U12.1 U12.9 U13.10 U13.11 U14.2 U15.3 U15.8 U16.11 U16.12 U16.13 U18.2 U18.6 U18.7 U18.8 U19.2 U19.6 U19.7 U19.8 U20.4 U21.4 U26.49 U27.3 U27.8 U28.3 U28.8 U29.8 U29.9 U30.8 U30.9 U31.1 U32.8 U32.9 U33.2 U34.3 U34.8 U35.2 U36.3 U36.8 U43.2 U43.5 U43.8 U44.2 U44.6 U44.7 U44.8 U45.2 U45.5 U45.8 U46.2 U46.6 U46.7 U46.8 U47.1 U48.11 U48.12 U48.13 U48.14 U49.2 U49.6 U49.7 U49.8 U50.4 U51.4 U53.2 U53.6 U53.7 U53.8 U54.4 U55.4 U64.2 U65.8 U65.9 U66.2 U67.2 U68.2 U69.3 U69.8 U70.3 U70.8 U71.3 U71.8 X1.1 XS1.1 Y1.2 Y1.4 Y2.2 Y2.4 | length 547.5
  Top Layer w0.15: C138.1@48.25,29.9 v1(48.25,30.65) ; C151.1@49.1,29.9 v1(49.1,30.65) ; C153.1@52.874,27.318 v1(52.874,28.068) ; C137.1@53.674,27.318 v1(53.674,28.068)
  Top Layer w0.2: U16.13@41.95,44.425 42.575,44.425 U16.12@42.6,44.45 42.6,45.2 v1(42.8,45.4) 43,45.2 U16.11@43,44.45
  Top Layer w0.25: v1(2.45,56.15) 2.45,55.675 2.775,55.35 2.775,54.725 R7.1@2.8,54.7 ; U7.9@2.675,57.225 2.525,57.225 v1(2.45,57.15) 2.45,57.4 U7.4@3.4,57.4 ; v1(4.05,73.142) 4.05,74.197 J15.SH2@4.081,74.228 J15.SH1@6.881,74.228 J15.1@6.881,75.478 ; C100.2@4.8,53.613 R52.1@4.8,54.713 5.492,54.713 5.705,54.5 v1(5.8,54.5) R54.1@6.5,54.5 ; v1(5.8,55.3) C101.2@6.5,55.3 ; v1(5.8,56.2) R57.1@6.5,56.2 ; v1(5.8,57.1) C103.2@6.5,57.1 ; R199.1@9.45,83.45 v1(10.15,83.45) ; v1(9.718,91.626) 9.784,91.56 9.784,90.994 C250.1@9.85,90.928 ; C247.1@9.85,86.128 v1(10.55,86.128) ; C249.1@9.85,86.928 v1(10.55,86.928) ; C251.1@9.85,87.728 v1(10.55,87.728) ; C248.1@9.85,88.528 v1(10.55,88.528) C245.1@11.3,88.528 ; C246.1@9.85,89.328 v1(10.55,89.328) ; C252.1@9.85,90.128 v1(10.55,90.128) ; v1(12.143,4.8) D33.1@12.837,4.8 ; v1(15.119,4.734) 15.125,4.728 S1.3@15.125,3.075 ; v1(17.9,4.8) D34.1@18.593,4.8 ; v1(19.15,11.5) Q13.2@19.15,10.35 19.225,10.35 20.125,9.45 R263.1@21.2,9.45 ; S2.3@20.825,3.075 v1@20.825,4.728 ; v1(23.6,21.9) C49.2@25.4,21.9 C46.1@25.4,22.7 C40.1@25.4,23.5 C36.1@25.4,24.3 C50.1@25.4,25.1 C26.1@25.4,25.9 C53.1@25.4,26.7 C33.1@25.4,27.5 C30.1@25.4,28.3 C44.1@25.4,29.1 C47.1@25.4,29.9 ; M1.50@24.5,65.6 M1.50@24.525,65.575 ; 24.525,64.587 24.725,64.387 v1(24.725,64.293) ; R21.2@26.3,32.35 v1(26.3,33.05) ; C61.1@28.095,44.13 v1(28.095,45.182) ; C25.1@28.1,24.35 C29.1@28.9,24.35 C54.2@29.7,24.35 C35.1@30.5,24.35 C32.1@31.3,24.35 C42.1@32.2,24.35 C38.1@33,24.35 ; C61.1@28.21,44.13 C61.1@28.215,44.125 ; v1(28.825,64.31) 28.825,64.405 v1@28.975,64.555 ; C37.1@28.9,27.1 C31.1@29.7,27.1 C34.2@30.5,27.1 C24.1@32.95,27.1 32.974,27.124 33.592,27.124 v1(33.616,27.147) ; M1.68@28.975,65.575 M1.68@29,65.6 ; C56.1@30.9,30.65 v1(30.9,31.35) ; C60.2@31.7,30.65 v1(31.7,31.35) ; C57.1@32.85,30.65 v1(32.85,31.35) ; C38.1@33.012,24.362 33.014,24.364 33.595,24.364 v1(33.61,24.379) ; C52.1@33.75,30.65 v1(33.75,31.35) ; v1(34.78,55.628) 34.847,55.561 35.039,55.561 R150.1@35.55,55.05 ; R26.1@35.402,34.651 35.404,34.653 v1(35.404,35.4) ; C20.2@35.477,25.775 v1(38.275,25.775) ; C18.1@35.477,26.575 v1(38.275,26.575) ; C62.1@35.679,23.03 v1@36.412,23.03 ; C59.2@36.179,21.156 36.298,21.275 36.705,21.275 36.916,21.486 v1(36.975,21.486) ; C55.2@36.179,21.956 36.298,22.075 36.67,22.075 36.746,22.15 36.883,22.15 v1(36.95,22.217) ; v1(40.65,39.5) 40.702,39.448 40.702,39.098 41.175,38.625 41.175,38.375 R272.2@41.35,38.2 ; v1(40.865,45.385) C176.1@40.865,46.3 ; v1(42.029,27.4) C141.1@42.85,27.4 ; C154.1@42.775,26.503 C154.1@42.813,26.466 ; v1(43,100.95) D18.2@43,101.775 ; C147.1@43.475,24.425 C147.1@43.6,24.3 ; v1(43.75,17.979) C160.1@43.75,18.8 ; v1(43.8,21.05) 43.895,21.05 44.245,21.4 C146.1@44.95,21.4 ; C162.1@44.575,18.803 v1(44.575,17.982) 45.153,17.982 45.299,18.128 45.299,18.678 C164.1@45.424,18.803 ; C143.1@44.95,22.25 45,22.25 45.125,22.375 45.125,22.825 v1(45.4,23.1) ; v2@46.2,24.767 46.3,24.867 C150.1@46.3,25.85 ; v1(46.688,17.708) v1@46.694,17.714 ; C136.1@46.7,18.95 46.694,18.944 v1@46.694,17.714 ; v2@47.331,22.265 47.783,21.813 47.783,21.525 47.908,21.4 C155.1@47.95,21.4 ; C133.1@47.55,18.95 47.55,18.232 47.084,17.767 46.747,17.767 v1@46.694,17.714 ; v2(48.679,25.825) 49.1,26.246 49.1,26.65 ; C148.1@48.95,18.95 48.95,18.083 49.325,17.708 v1(49.8,17.708) C152.1@49.8,19.6 ; v1(49,100.95) D6.2@49,101.775 ; v2(49.75,24.753) 49.75,24.8 C145.1@50.45,25.5 ; v2@49.8,23.396 49.81,23.387 49.81,22.866 50.047,22.628 50.375,22.628 50.5,22.503 C149.1@50.5,22.5 ; v2@49.81,23.406 50.398,23.994 C134.1@50.521,23.994 ; v1(51.95,97.65) C173.1@51.95,98.35 ; v1(55.425,40.9) R32.1@56.475,40.9 ; M1.167@55.75,57.4 M1.167@55.76,57.41 ; M1.170@56.5,65.6 v1(56.5,66.95) v1@56.525,66.925 ; v1(56.95,28.95) 57.65,28.95 C81.2@58,29.3 ; v1(56.954,35.646) 56.977,35.623 56.977,34.923 R40.1@57,34.9 ; v1(60.55,99.75) C14.1@61.25,99.75 61.75,99.25 U5.7@62.4,99.25 ; M1.194@62.5,65.6 M1.194@62.5,65.739 ; U5.4@65.2,100.25 v1(66.1,100.25) ; C95.1@66.1,35.625 v1(66.1,36.675) ; C94.1@68.4,35.625 v1(68.4,36.675) ; M1.224@70,65.6 M1.224@70.013,65.588 ; v1@70.013,64.337 v1(70.025,64.325) ; v1(76.75,52.506) 76.75,53.45 ; v1(78.35,52.506) 78.35,53.45 ; v1(79.95,52.506) 79.95,53.45 ; v1(80.78,50.542) D3.2@80.78,51.486 ; R49.1@80.8,17.65 v1(80.8,18.4) ; v1(80.8,21.3) D4.2@81.575,21.3 ; v1(81.55,52.506) 81.55,53.45 ; v1(82.62,50.542) D3.1@82.62,51.486 ; C97.2@83.15,17.25 v1(83.15,17.95) ; v1(83.15,52.506) 83.15,53.45 ; v1(85.05,65.175) R27.1@85.05,65.912 ; v1(85.6,39.75) R46.1@85.6,40.478 ; v1(86,65.15) R38.1@86,65.95 ; R33.1@86.8,37.678 v1(87.528,37.678) ; R34.1@86.8,38.578 v1(87.528,38.578) ; v1(87.28,95.383) 87.288,95.391 87.288,96.146 R198.1@87.295,96.153 ; U10.3@87.75,68.325 87.75,69 ; 88.25,69 U10.5@88.25,69.675 ; R185.1@89.95,28.15 v1(89.95,28.887) ; v1(92.969,22.774) 92.979,22.784 C120.2@94.788,22.784 ; R197.1@94.175,96.173 94.187,96.162 94.938,96.162 v1(94.95,96.15)
  Top Layer w0.3: v1(14.5,64.35) M1.10@14.5,65.6 ; M1.11@14.75,57.4 v1(14.75,58.65) ; v1(16.5,64.35) M1.18@16.5,65.6 ; M1.27@18.75,57.4 v1(18.75,58.65) ; v1(19,64.35) M1.28@19,65.6 ; M1.33@20.25,57.4 v1(20.25,58.65) ; M1.39@21.75,57.4 v1(21.75,58.65) ; v1(22,64.35) M1.40@22,65.6 ; M1.45@23.25,57.4 v1(23.25,58.65) ; 24.525,64.587 M1.50@24.525,65.575 ; M1.51@24.75,57.4 v1(24.75,58.65) ; M1.65@28.25,57.4 v1(28.25,58.65) ; v1@28.975,64.555 M1.68@28.975,65.575 ; M1.71@29.75,57.4 v1(29.75,58.65) ; M1.77@31.25,57.4 v1(31.25,58.65) ; M1.83@32.75,57.4 v1(32.75,58.65) ; M1.86@33.5,65.6 v1(33.5,66.85) ; M1.89@34.25,57.4 v1(34.25,58.65) ; M1.97@36.25,57.4 v1(36.25,58.65) ; v1(36.5,64.35) M1.98@36.5,65.6 ; M1.103@37.75,57.4 v1(37.75,58.65) ; M1.109@39.25,57.4 v1(39.25,58.65) ; v1(39.5,64.35) M1.110@39.5,65.6 ; M1.115@40.75,57.4 v1(40.75,58.65) ; M1.121@42.25,57.4 v1(42.25,58.65) ; v1(42.5,64.35) M1.122@42.5,65.6 ; M1.127@43.75,57.4 v1(43.75,58.65) ; v1(45.5,64.35) M1.134@45.5,65.6 ; M1.145@50.25,57.4 v1(50.25,58.65) ; v1(50.5,64.35) M1.146@50.5,65.6 ; v1(53.5,64.35) M1.158@53.5,65.6 ; v1(55.697,56.137) v1(55.697,56.137) 55.7,56.139 55.75,56.139 M1.167@55.75,57.4 ; v1(57.2,58.65) 57.25,58.65 M1.173@57.25,57.4 ; M1.179@58.75,57.4 58.75,58.65 v1(58.8,58.65) ; v1(59.5,64.35) M1.182@59.5,65.6 ; v1(62.5,64.35) M1.194@62.5,65.6 ; M1.195@62.75,57.4 v1(62.75,58.65) ; v1(65,64.375) M1.204@65,65.6 ; M1.209@66.25,57.4 66.25,58.55 v1(66.354,58.654) ; M1.223@69.75,57.4 v1(69.75,58.65) ; v1@70.013,64.337 M1.224@70.013,65.588 ; M1.229@71.25,57.4 v1(71.25,58.625) ; v1(71.5,64.325) M1.230@71.5,65.6 ; v1(73,64.325) M1.236@73,65.6 ; v1(74.5,64.325) M1.242@74.5,65.6 ; M1.243@74.75,57.4 v1(74.75,58.65)
  Top Layer w0.35: v1(8.45,51.05) D32.2@9.15,51.05
  Top Layer w0.4: v1(2.868,93.528) 3.781,93.528 J15.SH3@4.081,93.228 ; v1(2.913,76.978) J15.4@4.081,76.978 ; v1(2.913,79.978) J15.10@4.081,79.978 ; v1(2.913,82.978) J15.16@4.081,82.978 ; v1(2.913,89.978) J15.30@4.081,89.978 ; J15.7@6.881,78.478 v1(8.05,78.478) ; J15.13@6.881,81.478 v1(8.05,81.478) ; J15.SH4@6.881,93.228 8.474,93.228 8.746,93.5 v1(8.8,93.5) ; v1(40.65,39.5) C114.1@41.45,39.5 ; C111.1@44.6,39.5 v1(45.4,39.5) ; v1(56.12,99.875) U31.1@56.12,100.575 ; v1(57.525,99.475) C167.1@57.525,100.175
  Top Layer w0.5: U7.9@2.5,57.2 C16.1@2.5,58.5 ; J4.B1/A12@7.35,44.65 v1(8.45,44.65) ; J4.A1/B12@7.35,51.05 v1(8.45,51.05) ; v1(8,99.3) C102.1@8,100.5 ; v1(10.3,99.125) R55.2@10.3,100.1 ; v1(14.625,39.987) 14.644,39.968 14.644,39.874 14.947,39.57 14.947,38.975 15.347,38.575 J12.10@15.363,38.575 ; v1(18.8,26.6) 19.231,27.031 C21.1@19.231,27.181 ; v1(19.35,28.1) C161.1@19.35,28.8 ; v1(19.587,38.7) U66.2@19.587,39.675 ; v1(20.2,28.1) C157.1@20.2,28.8 ; v1(21.47,33.68) J13.3@23.3,33.68 ; v1(21.47,34.95) J13.5@23.3,34.95 ; v1(23.2,38.75) U67.2@23.2,39.725 ; C48.2@27.3,32.35 v1(27.3,33.05) ; C45.1@28.35,32.35 v1(28.35,33.05) ; C66.1@32.465,34.95 v1(33.454,34.95) ; U9.8@34.005,37.05 34.156,36.899 34.156,36.194 v1(34.6,35.75) ; v1(34.315,52.3) U32.8@35.26,52.3 ; v1(35.875,45.25) C174.1@36.79,45.25 ; C65.1@36.25,32.85 v1(36.25,33.55) ; C64.1@37.1,32.85 v1(37.1,33.55) ; 39.5,54.55 v1(40.445,54.55) ; R29.2@58.5,44.2 v1(58.5,45.25) ; C84.2@61.15,31.9 61.15,33.785 U11.7@61.035,33.9 61.035,35.235 v2(61.6,35.8) ; C73.1@64.4,41.8 v1(65.45,41.8) ; C77.1@64.4,45 v1(65.55,45) ; C92.1@74.15,34 v1(75.2,34) ; C96.1@74.175,26.5 v1(75.225,26.5) ; C98.1@74.175,29 v1(75.225,29) ; C99.1@74.175,31.5 v1(75.225,31.5) ; v1(76.15,27.4) C70.1@77.35,27.4 ; v1(76.15,30) C72.1@77.35,30 ; v1(76.15,32.6) C75.1@77.35,32.6 ; v1(76.15,35.2) C76.1@77.35,35.2 ; v1(79.667,38.6) U12.1@80.395,38.6 ; R31.2@84.4,34.828 v1(85.45,34.828) ; C78.1@85.65,30 v1(86.85,30) ; C79.1@85.65,32.6 v1(86.85,32.6) ; C71.1@88.775,76.7 v1(89.9,76.7) ; C74.1@88.777,74.654 v1(89.902,74.654) ; v1@90.832,31.521 93.079,31.521 93.372,31.228 93.372,30.785 C219.2@93.422,30.785 ; v1(92.55,36.55) 92.567,36.567 93.305,36.567 C220.2@93.322,36.585 ; v1(92.791,34.027) 94.06,32.758 U51.4@96.191,32.758 ; v1(92.969,45.875) 92.969,45.872 93.917,44.924 C229.2@94.594,44.924 U55.4@96.37,44.924 ; C88.1@93.65,69.8 94.134,69.8 94.812,70.478 94.812,70.55 v1(94.831,70.569) 96.594,70.569 R256.1@96.6,70.563 ; C86.1@93.65,71.4 94.392,71.4 v1(94.831,71.839) ; C89.1@93.75,76.65 v1(94.85,76.65) ; C91.1@93.75,78.25 94.387,78.25 94.812,77.825 94.812,77.598 v1(94.831,77.579) ; C116.1@94.475,15.9 94.624,16.049 95.354,16.049 95.712,16.407 95.712,16.506 v1(95.731,16.525) ; v1(94.831,93.862) 94.834,93.859 96.594,93.859 R262.1@96.6,93.853 ; v1@95.72,16.437 U21.4@95.72,17.695 ; v1(96.191,26.245) U50.4@96.191,26.982 ; C228.2@96.3,51.05 v1(96.3,51.9) ; U54.4@96.347,39.124 96.347,38.303 v1(96.35,38.3) ; v1(97.8,7.9) 99.99,7.9 L12.3@100.01,7.88 ; v1(100.05,6.35) 100.05,7.84 L12.3@100.01,7.88 ; v1(101.5,6.35) 101.5,7.14 100.76,7.88 L12.3@100.01,7.88 ; v1(104.099,10.309) v1(104.099,10.309) C119.2@105.78,10.31 ; C115.1@107.325,2.71 v1(107.325,3.848) 107.325,5.141 U20.4@107.439,5.255
  Top Layer w0.75: J12.12@1.213,27.025 2.875,27.025 3.55,26.35 v1(3.55,25.4) ; v1(2.05,37.15) 2.05,40.012 J12.11@2.213,40.175 ; v1@2.085,37.185 J12.6@4.303,37.185 ; v1(14.7,35.375) 14.7,35.3 15.363,34.637 J12.13@15.363,32.875 ; v1(17.45,20.7) 18.481,20.7 18.919,21.137 18.919,22.35 v1(19.65,22.35)
  Bottom Layer w0.15: v1(2.25,22.8) Q1.1@2.25,23.475 ; v1(3.25,21.45) Q1.4@3.25,22.125 ; v1(4.05,24.25) 4.45,23.85 Q2.1@4.45,23.475 ; Q2.4@5.45,22.125 v1(6.075,22.125) ; R82.1@10,22.15 v1(10.85,22.15) ; v1(11.489,23.49) Q3.1@12.114,23.49 ; Q3.4@13.114,22.14 v1(13.739,22.14) ; v1(14.089,23.49) Q4.1@14.714,23.49 ; Q4.4@15.714,22.14 v1(16.339,22.14) ; U13.11@18.65,48.5 18.65,48.075 v1(18.85,47.875) 19.05,48.075 U13.10@19.05,48.5
  Bottom Layer w0.2: U8.40@31.711,21.8 v1(31.711,22.606) ; R273.1@61.85,59.85 61.85,59.826 62.75,58.926 v1(62.75,58.65) ; v1(65,64.375) 65.077,64.452 65.077,64.72 R84.1@65.35,64.993 ; U48.14@67.2,59.8 67.2,60.3 67.35,60.45 U48.12@67.625,60.45 ; U48.13@67.6,59.8 67.6,60.425 U48.12@67.625,60.45 ; v1(68.492,61.208) 68.5,61.2 68.15,60.85 U48.11@67.625,60.85 U48.12@67.625,60.45
  Bottom Layer w0.25: R66.2@1.15,49.15 v1(2.05,49.15) ; C109.1@1.45,46.75 1.45,45.5 1.833,45.117 1.933,45.117 v1(2,45.05) ; v1(2.25,18.7) R70.1@2.25,19.5 ; R62.1@2.45,29.5 2.45,30.7 2.75,31 ; R67.1@2.75,25.4 v1(3.55,25.4) ; v1(2.868,93.528) C244.1@4.05,93.528 ; v1(4.95,18.7) R74.1@4.95,19.5 ; R71.1@4.95,25.4 v1(5.75,25.4) ; R206.1@8.031,95.028 8.042,95.039 8.789,95.039 v1(8.8,95.05) ; C243.1@8.05,93.528 8.064,93.514 8.786,93.514 v1(8.8,93.5) ; v1(9.42,46.6) U15.3@10.17,46.6 ; v1(9.85,25.15) R156.2@9.85,26.2 ; U15.8@10.987,46.6 v1(11.738,46.6) ; R75.1@11.614,24.415 v1(11.614,25.215) ; v1(11.817,97.547) C239.1@12.675,97.547 ; v1(12.3,35.35) U36.8@13.008,35.35 ; v1(12.3,40) 12.971,40 U34.8@12.983,39.987 ; v1(12.614,18.715) R78.1@12.614,19.515 ; J9.C5@13.245,73.84 v1(14.153,73.84) ; U34.3@13.8,39.987 v1(14.625,39.987) ; U36.3@13.825,35.35 13.838,35.363 14.687,35.363 v1(14.7,35.375) ; R79.1@14.214,24.415 v1(14.214,25.215) ; R60.1@14.9,51.4 v1(14.9,52.35) ; v1(15.301,18.732) 15.308,18.739 15.308,19.508 R81.1@15.314,19.515 ; v1(17.05,46.75) C106.1@17.05,47.497 ; R202.1@17.85,85.775 v1(18.772,85.775) ; v1(19.84,82.65) C177.1@20.7,82.65 C177.1@20.75,82.65 ; v1(19.84,84.1) C178.1@20.7,84.1 C178.1@20.75,84.1 ; v1(19.84,85.55) C179.1@20.7,85.55 C179.1@20.75,85.55 ; Q11.1@21.175,16.25 v1(21.85,16.25) ; Y1.4@21.8,24.375 21.8,25.6 v1(21.8,26.15) ; v1(21.861,17.25) Q11.4@22.525,17.25 ; R205.1@22.625,95.15 22.637,95.137 22.637,94.463 v1(22.65,94.45) ; C23.1@22.8,21.9 v1(23.6,21.9) 23.667,21.967 23.667,22.267 23.885,22.485 24.335,22.485 C43.1@24.4,22.55 ; Y1.2@22.8,23.025 v1(23.6,23.025) ; v1(25.35,18.175) U71.3@25.35,18.925 U71.8@25.35,19.742 ; v1(28.49,79.7) C175.1@29.4,79.7 ; v1(28.65,2.4) R214.2@28.65,3.4 ; U70.8@29.2,19.742 U70.3@29.2,18.925 29.213,18.912 29.213,18.226 v1(29.225,18.214) ; v1(31.05,2.55) C257.1@31.05,3.8 ; v1(31.711,22.606) 31.711,24.547 U8.69@30.511,25.747 31.911,27.147 v1(33.616,27.147) ; U69.3@33.35,19.675 U69.8@33.35,18.858 33.416,18.792 33.416,18.288 v1(33.482,18.222) ; v1(35.2,18.95) C28.1@35.2,19.7 ; R212.1@37.05,30.85 37.075,30.875 37.075,33.525 v1(37.1,33.55) ; v1(38.341,18) R20.2@38.341,19.05 ; v1(39.031,25.15) Y2.2@39.975,25.15 ; v1(39.55,17.8) C156.1@40.55,17.8 ; v1(40,26.7) C142.1@40.8,26.7 ; v1@40.511,19 R122.2@41.25,19 ; C139.1@41,21.4 v1@41.739,21.4 ; Y2.4@41.825,22.85 v1(41.825,23.925) ; v1(44.25,91.5) C172.1@45,91.5 ; v1(45.4,23.1) 46.075,23.1 46.2,23.225 U26.49@46.2,23.396 ; v1(46.688,17.708) 46.694,17.714 46.694,18.452 U27.8@46.7,18.458 U27.3@46.7,19.275 ; v1(47.45,5.6) R131.2@47.45,6.6 ; v1(49.8,17.708) U28.8@49.8,18.458 U28.3@49.8,19.275 ; v1(49.85,5.75) C163.1@49.85,7 ; R268.2@51.7,18.6 51.875,18.425 51.875,18.17 52.1,17.945 v1(52.1,17.85) ; v1(54.4,19.8) R128.2@55.4,19.8 ; R266.2@54.65,18.6 v1(55.4,18.6) ; v1(55.35,17.5) 55.363,17.488 55.987,17.488 Q14.1@56,17.475 ; v1@56.1,93.19 v1(56.104,93.194) 57.043,93.194 Q8.2@57.047,93.199 ; v1(56.108,82.299) Q6.2@57.047,82.299 ; v1(56.108,87.649) Q7.2@57.047,87.649 ; v1@56.208,76.899 Q5.2@57.147,76.899 ; Q14.4@57,16.125 v1(57,16.8) ; v1@57.108,83.849 R107.1@57.847,83.849 ; v1(57.15,78.44) 57.154,78.444 57.893,78.444 R106.1@57.897,78.449 ; v1@57.158,89.349 R108.1@57.897,89.349 ; v1@57.158,94.849 R109.1@57.897,94.849 ; R130.2@61.4,22.35 v1(61.4,23.35) ; v1@64.35,47.011 R118.1@64.35,47.75 ; v1(65.304,47.007) 65.327,47.03 65.327,47.727 R114.1@65.35,47.75 ; v1@66.35,47.011 R116.1@66.35,47.75 ; v1(67.55,6.25) C2.1@67.55,7.5 ; v1(67.95,70.3) 69.05,70.3 ; v1(69.025,67.85) C11.1@69.75,67.85 ; v1(69.275,71.5) C9.1@70,71.5 ; v1@70.025,64.255 v1(70.025,64.325) ; v1(70.05,6.15) R3.2@70.05,7.1 ; v1(71.95,20.533) U2.3@71.95,21.283 U2.8@71.95,22.1 ; U3.2@72.35,68.45 U3.33@73.5,68.45 ; U3.32@73,67.3 73,67.95 U3.33@73.5,68.45 ; U3.9@73,72.1 73,71.45 v2(73.607,70.843) ; v2(73.607,68.557) U3.33@73.5,68.45 ; v2(75.893,68.557) 76,68.45 U3.23@77.15,68.45 ; v2(75.893,70.843) 76.5,71.45 U3.16@76.5,72.1 C13.1@76.5,73.35 v1(77.225,73.35) ; v1(76.162,20.52) U1.3@76.163,21.27 U1.8@76.163,22.087 ; C10.1@78.6,67.8 78.613,67.812 79.312,67.812 v1(79.325,67.825) ; C209.1@85.5,49.845 v1(86.25,49.845) ; v1(87.55,46.4) C216.1@88.3,46.4 ; v1(89.2,49.335) 89.2,49.24 89.575,48.865 89.575,48.125 U47.1@89.65,48.05 ; v1(89.3,70.2) 89.395,70.2 89.795,70.6 R176.1@90.55,70.6 ; v1(89.696,91.648) 89.7,91.653 R178.1@90.6,91.653 ; v1@90.238,30.25 C218.2@90.95,30.25 ; v1(90.25,19.1) R89.1@91,19.1 ; v1@90.788,43.307 R192.1@91.5,43.307 ; v1(90.809,31.521) R188.1@91.522,31.523 ; v1@92.792,34.028 U49.6@94.172,34.028 ; v1@92.792,35.298 U49.7@94.172,35.298 ; v1(101.5,6.35) 101.54,6.39 101.735,6.39 101.75,6.405 102.125,6.405 R88.1@102.3,6.58 ; D26.2@122.985,96.45 D26.2@123.015,96.42 ; v1(125.525,87.275) v1@125.535,87.265
  Bottom Layer w0.3: C213.1@60.45,60.7 60.4,60.75 60.4,61.15 60.6,61.35 v1(60.6,61.5) ; v1(62.5,63.55) 62.8,63.25 C215.1@62.8,62.8
  Bottom Layer w0.4: v1(23.746,10.512) D31.1@24.421,10.512
  Bottom Layer w0.5: C241.1@2.6,96.111 v1(2.6,96.9) ; C241.1@2.611,96.1 2.611,96.05 2.818,96.05 2.84,96.028 v1(5.2,96.028) ; C108.1@5.85,35.5 v1(6.65,35.5) ; R63.1@5.85,36.4 v1(6.65,36.4) ; C104.1@7.15,34.225 7.25,34.325 v1(7.25,35.95) ; U14.2@7.36,29.55 v1(8.4,29.55) ; v1(9.55,30.65) C182.1@10.2,30.65 ; v1(10.3,99.125) 11.175,99.125 C240.1@11.5,99.45 ; U35.2@14.026,28.681 v1(15.066,28.681) ; v1(16.881,16.975) 16.9,16.994 17.775,16.994 R216.1@17.831,17.05 ; C258.1@17.45,19.7 v1(17.45,20.7) ; 17.6,29.65 v1(18.64,29.65) ; U68.2@19.611,21.255 19.631,21.274 19.631,22.331 v1(19.65,22.35) ; U33.2@20.405,79.7 v1(21.455,79.7) ; v1(20.725,94.745) U65.8@20.725,95.645 ; C242.1@22.875,99.45 v1(22.875,100.35) ; C39.1@25.65,35.2 v1(25.65,35.9) ; J8.4@28.8,81.4 v1(28.8,82.85) ; v1(30.8,88.15) J8.9@30.8,89.6 v1(30.8,91.091) ; v1(33.2,88.15) J8.15@33.2,89.6 ; XS1.1@35.02,97.85 35.02,95.495 38.8,91.715 v1(38.8,91.05) J8.21@38.8,89.6 v1(38.8,88.15) ; J8.18@37.6,81.4 v1(37.6,82.85) ; J8.26@40.8,81.4 v1(40.8,82.85) ; C171.1@41.2,79.4 41.773,79.4 41.923,79.55 v1(41.95,79.55) ; v1(41.2,88.15) J8.27@41.2,89.6 ; v1(42,88.15) J8.29@42,89.6 ; J8.34@44,81.4 v1(44,82.85) ; v1(44.4,88.15) J8.35@44.4,89.6 ; v1(45.154,88.104) 45.177,88.127 45.177,89.577 J8.37@45.2,89.6 ; J8.40@46.4,81.4 v1(46.4,82.85) ; v1(47.6,88.15) J8.43@47.6,89.6 ; J8.50@50.4,81.4 v1(50.4,82.85) ; C170.1@52.2,79.5 v1(52.95,79.5) ; U29.8@55.86,21.9 55.947,21.987 55.947,23.027 56.565,23.644 v2(56.565,23.8) ; U6.4@57.556,72.751 v1(57.556,73.551) ; C165.1@59.4,20.15 v1(60.2,20.15) ; C158.1@59.4,28.595 60.566,28.595 v1(60.579,28.582) ; v1(61.186,67.546) C15.1@61.986,67.546 ; U30.8@63.23,21.9 63.381,22.051 63.381,22.692 63.384,22.695 63.384,23.093 63.935,23.644 v2(63.935,23.8) ; v1(63.95,19.8) C166.1@64.75,19.8 ; C159.1@65.77,29.88 v1(65.77,30.83) ; v1(89.15,39.45) 89.168,39.468 C226.1@90.275,39.468 ; v1(89.236,88.003) 89.236,87.914 89.597,87.553 C211.2@90.6,87.553 ; v1(89.25,68) 89.25,66.922 C212.1@89.354,66.818 ; v1(89.25,88.85) 89.25,90.028 C214.1@89.275,90.053 ; v1(89.55,53) C207.1@90.3,53 ; v1(89.65,64.2) C210.2@90.4,64.2 ; v1(89.95,28.887) 89.95,27.725 C217.1@89.975,27.7 ; v1(90.45,17.7) C118.2@91.2,17.7 ; v1(90.787,42.005) C227.2@91.5,42.007 ; C208.1@92.5,74.853 92.5,74.3 92.783,74.017 93.633,74.017 v1(93.65,74) ; v1(92.55,36.55) 92.568,36.568 U49.8@94.172,36.568 95.682,36.568 96.132,36.118 R244.2@97.5,36.118 ; v1(92.8,28.948) U49.2@94.172,28.948 ; v1(92.969,45.875) v1(92.969,45.875) 94.349,45.874 U53.6@94.35,45.873 ; v1(92.969,47.075) 93.003,47.109 94.316,47.109 U53.7@94.35,47.143 ; v1@92.97,21.505 U19.6@94.35,21.505 ; v1@92.97,22.775 U19.7@94.35,22.775 ; v1@92.97,24.045 U19.8@94.35,24.045 ; v1(92.969,40.792) U53.2@94.35,40.793 ; U43.2@93.45,54.288 v1@94.83,54.288 ; U43.5@93.45,58.098 v1@94.83,58.098 ; U43.8@93.45,61.908 v1@94.83,61.908 ; U44.2@93.45,65.488 v1(94.831,65.489) ; U44.6@93.45,70.568 v1(94.831,70.569) ; U44.7@93.45,71.838 v1(94.831,71.839) ; U44.8@93.45,73.108 v1(94.831,73.109) ; U45.2@93.45,77.578 v1(94.831,77.579) ; U45.5@93.45,81.388 v1(94.831,81.389) ; U45.8@93.45,85.198 v1(94.831,85.199) ; U46.2@93.45,88.778 v1(94.831,88.779) ; U46.6@93.45,93.858 93.452,93.86 94.829,93.86 v1(94.831,93.862) ; U46.8@93.45,96.398 94.642,96.398 94.89,96.15 v1(94.95,96.15) ; U46.7@93.452,95.13 v1@94.829,95.13 ; U19.2@94.35,16.425 94.4,16.475 95.654,16.475 95.704,16.525 v1(95.731,16.525) ; U53.8@94.35,48.413 95,48.413 95.05,48.463 95.05,49.069 95.456,49.475 v1(95.456,49.502) ; v1(96.35,38.3) 96.771,38.721 97.125,38.721 97.5,39.096 R250.2@97.5,39.318 ; v1(96.5,15.2) R240.1@97.5,15.2 ; v1(101.5,5.33) C117.2@102.29,5.33 ; v1(104.069,3.984) U18.2@105.45,3.985 ; v1(104.069,9.064) 108.305,9.065 108.6,9.36 108.6,9.66 108.225,10.035 107.385,10.035 107.085,10.335 U18.7@105.45,10.335 ; v1(104.099,10.309) U18.7@105.48,10.31 ; U18.8@105.45,11.605 105.456,11.611 106.838,11.611 v1(106.843,11.617) ; v1@122.985,95.135 D26.2@122.985,96.45 ; v1@125.535,87.265 D23.2@126.85,87.265
  Bottom Layer w0.6: C253.1@17.2,25.425 17.675,25.9 v1(18.55,25.9)
  Bottom Layer w1: v1(2.45,30.445) 2.75,30.745 C107.1@2.75,31.55
  other v1: 98.6,3.29 100.05,3.29 101.5,3.29 98.6,4.31 100.05,4.31 101.482,4.31 20.819,4.734 98.6,5.33 100.05,5.33 98.6,6.35 40.507,18.996 27.25,20.65 25.2,21.25 41.743,21.404 92.969,21.504 36.417,23.036 92.969,24.044 75.2,27.4 76.175,29 24.356,29.088 75.2,30 87.8,30 90.237,30.249 86.85,30.95 87.8,30.95 76.175,31.5 75.2,32.6 76.15,34 86.4,34.828 92.791,35.297 67.45,36.675 88.478,37.678 88.478,38.578 80,40.5 84.6,40.5 80,41.7 84.6,41.7 30.015,43.292 90.787,43.305 64.354,47.007 66.354,47.007 9.4,48.45 94.831,54.289 94.831,58.099 50.3,59.75 52.3,61.15 94.831,61.909 86.3,69.05 88.8,69.05 16.25,70.2 17.95,70.25 19.9,70.4 14.5,72.25 56.204,76.894 57.104,83.844 57.154,89.344 60.354,93.644 57.154,94.844 94.831,95.132 122.975,95.125
  other v2: 47.322,22.325 48.679,22.325 46.25,23.396 47.322,23.396 48.679,23.396 49.75,23.396 57.765,23.8 58.965,23.8 65.135,23.8 66.335,23.8 46.25,24.753 47.322,24.753 48.679,24.753 56.565,25 57.765,25 58.965,25 63.935,25 65.135,25 66.335,25 47.322,25.825 59.2,35.8 60.4,35.8 59.2,37 60.4,37 61.6,37 30.9,38.95 32.1,38.95 33.3,38.95 30.9,40.15 32.1,40.15 33.3,40.15 81.1,40.5 82.3,40.5 83.5,40.5 81.1,41.7 82.3,41.7 83.5,41.7 35.965,49.2 37.165,49.2 38.365,49.2 35.965,50.4 37.165,50.4 38.365,50.4 74.75,68.557 73.607,69.7 74.75,69.7 75.893,69.7 74.75,70.843 17.625,96.35 18.825,96.35 17.625,97.55 18.825,97.55 17.625,98.75 18.825,98.75
GND_232: C230.2 C231.2 C232.2 C233.1 C236.1 C237.1 C238.1 J6.13 J6.14 R250.1 U53.9 U53.10 U53.11 U53.12 U53.15 U53.16 U54.5 U55.5 U56.15 U57.3 U58.3 X78.1 | length 34.5
  Top Layer w0.25: U56.15@105.225,43.443 107.17,43.443 107.242,43.37 v1(107.337,43.37) ; v1@105.432,48.768 v1(105.45,48.75)
  Top Layer w0.5: U54.5@101.808,39.124 103.551,39.124 103.927,39.5 v1(105.4,39.5) ; v1(101.811,44.122) 101.82,44.131 101.82,44.914 U55.5@101.831,44.924 ; C231.2@104.6,48.768 v1@105.432,48.768 ; C237.1@106.95,41.368 107.3,41.718 107.418,41.718 v1(107.85,42.15) ; C236.1@107.2,48.768 X78.1@107.2,50.45 ; C238.1@109.05,41.368 v1(109.05,42.25)
  Bottom Layer w0.25: v1@107.831,42.169 v1(107.85,42.15)
  Bottom Layer w0.5: R250.1@100.7,39.318 101.941,39.318 102.146,39.523 U53.16@103.85,39.523 103.873,39.5 v1(105.4,39.5) 105.4,40.284 104.941,40.743 103.9,40.743 U53.15@103.85,40.793 ; v1(101.811,44.122) 101.856,44.122 102.337,44.603 U53.12@103.85,44.603 ; U53.11@103.85,45.873 105.6,45.873 105.873,45.6 v1(106.95,45.6) ; U53.10@103.85,47.143 105.518,47.143 105.925,47.55 v1(106.85,47.55) ; U53.9@103.85,48.413 105.113,48.413 v1(105.45,48.75) ; C230.2@106.611,42.169 v1@107.831,42.169 ; C232.2@106.624,43.369 v1@107.336,43.369 ; C233.1@109.063,40.368 v1@110.443,40.368 ; U58.3@112.95,40.3 v1(112.95,41.1) ; v1(112.95,42.567) U57.3@112.95,43.9
  other v1: 110.444,40.369
GND_485: C221.2 C222.2 C223.2 C224.1 C225.2 J6.9 J6.11 R244.1 U49.9 U49.10 U49.11 U49.12 U49.15 U49.16 U50.5 U51.5 U51.6 U52.2 U52.5 U59.3 X70.1 | length 33.3
  Top Layer w0.25: X70.1@106.448,29.498 X70.1@106.45,29.5
  Top Layer w0.5: U50.5@101.652,26.982 103.367,26.982 v1(103.4,26.95) ; U51.5@101.652,32.758 v1(105.053,32.759) v1(105.053,32.759) ; U51.6@101.652,34.028 v1(105.053,34.029) v1(105.053,34.029) ; C222.2@103.522,35.563 103.522,35.54 104.11,35.54 104.386,35.264 v1(105.153,35.264) ; v1(107.95,31.55) C225.2@107.95,32.3 ; U52.2@110.415,27.869 v1@110.415,29.309 ; v1(112.947,31.883) 112.951,31.887 112.951,33.327 U52.5@112.955,33.33 ; U59.3@115.5,31.45 v1(115.5,32.6)
  Bottom Layer w0.25: U49.15@103.672,28.948 103.76,28.859 106.259,28.859 X70.1@106.45,29.05 ; U49.12@103.672,32.758 v1(105.053,32.759) ; U49.11@103.672,34.028 v1(105.053,34.029)
  Bottom Layer w0.5: v1(103.4,26.95) 103.4,27.503 103.575,27.678 U49.16@103.672,27.678 ; U49.9@103.622,36.518 100.95,36.518 100.7,36.268 100.7,35.818 101.22,35.298 U49.10@103.672,35.298 ; U49.10@103.672,35.263 v1@105.152,35.263 ; U49.9@103.722,36.518 105.05,36.518 v1(105.1,36.468) ; X70.1@106.45,29.5 C223.2@106.45,30.488 ; C224.1@109.025,36 v1(110.15,36)
  other v1: 110.423,29.317
GND_AIN1: C183.2 C190.1 C191.1 C194.2 C195.1 C197.1 C199.1 C200.1 C203.1 C205.2 JP1.1 PTC5.2 Q9.1 Q9.4 R167.1 R175.1 R256.2 U37.1 U37.2 U37.3 U39.1 U39.2 U39.4 U39.5 U39.8 U41.2 U43.9 U43.15 U44.9 U44.10 U44.11 U44.12 U44.15 U44.16 X59.1 | length 46.1
  Top Layer w0.5: v1(101.569,69.297) 100.766,69.297 99.8,70.263 R256.2@99.8,70.563 ; v1(101.569,71.837) 100.774,71.837 99.8,70.863 R256.2@99.8,70.563 ; v1(101.607,70.569) 99.806,70.569 R256.2@99.8,70.563 ; PTC5.2@106.884,61 106.9,60.984 v1(106.9,58.75)
  Bottom Layer w0.25: v1(104.469,71.961) U41.2@105.532,71.961 ; C197.1@104.95,65.2 v1(104.95,65.928) 104.979,65.928 105.3,66.25 105.3,66.283 105.707,66.69 C205.2@105.757,66.69 ; U39.8@104.975,55.75 v1(104.975,57.35) ; U39.5@106.925,55.75 v1(106.925,57.35) ; C195.1@106.95,65.2 106.987,65.237 106.987,65.885 v1(107.023,65.922) ; C200.1@107.06,68.318 v1(107.06,69.49) ; U39.4@107.575,55.75 v1(107.575,56.975) ; C199.1@107.75,65.2 v1(107.75,65.928) ; U39.2@108.875,55.75 v1(108.875,56.975) ; U39.1@109.525,55.75 v1(109.525,57.35) ; v1(110.3,58.45) 110.35,58.5 Q9.1@111.05,58.5 ; C190.1@110.76,71.965 v1(111.488,71.965) ; R167.1@110.76,72.915 v1(111.488,72.915) ; Q9.4@112.4,59.5 112.909,59.5 113.006,59.597 114.003,59.597 114.675,58.925 U37.2@114.675,57.727 ; v1@113.302,57.726 U37.1@114.014,57.726 ; v1(113.6,53.85) C183.2@114.35,53.85 ; R175.1@114.601,59 v1(115.35,59) 115.325,58.975 U37.3@115.325,57.727
  Bottom Layer w0.5: v1@101.57,64.218 U44.16@102.95,64.218 ; v1@101.57,65.488 U44.15@102.95,65.488 ; v1@101.57,69.298 U44.12@102.95,69.298 ; v1@101.57,71.838 U44.10@102.95,71.838 ; v1(101.607,70.569) U44.11@102.988,70.57 ; U43.15@102.969,54.289 v1@104.349,54.289 ; U43.9@102.969,61.909 v1@104.349,61.909 ; U44.9@102.987,73.111 102.988,73.11 104.368,73.11 v1(104.369,73.111) ; C203.1@106.254,53.167 106.965,53.167 v1(106.967,53.168) ; v1(108.66,67.815) C194.2@108.66,68.543 ; C191.1@110.25,67.475 v1(111.428,67.475) ; JP1.1@114.6,61.2 114.6,60.332 114.719,60.213 v1(114.719,60.119)
  other v1: 104.35,54.29 113.301,57.725 104.35,61.91 101.569,64.217 101.569,65.487
GND_AIN2: C184.2 C189.1 C192.1 C193.2 C196.1 C198.1 C201.1 C202.1 C204.1 C206.2 JP2.1 PTC6.2 Q10.1 Q10.4 R166.1 R174.1 R262.2 U38.1 U38.2 U38.3 U40.2 U40.4 U40.5 U40.8 U42.2 U45.9 U45.15 U46.9 U46.10 U46.11 U46.12 U46.15 U46.16 X58.1 | length 44.4
  Top Layer w0.5: v1(101.55,92.586) 100.767,92.586 99.8,93.553 R262.2@99.8,93.853 ; v1(101.55,95.126) 100.773,95.126 99.8,94.153 R262.2@99.8,93.853 ; v1(101.588,93.858) 99.805,93.858 R262.2@99.8,93.853 ; v1(106.884,82) PTC6.2@106.884,84.2 PTC6.2@106.884,84.234
  Bottom Layer w0.25: v1(109.775,81.528) 109.8,81.553 Q10.1@110.725,81.553 ; C189.1@110.7,95.35 v1(111.428,95.35) ; R166.1@110.7,96.3 v1(111.428,96.3) ; Q10.4@112.075,82.553 112.511,82.553 112.883,82.925 113.188,82.925 113.197,82.915 113.442,82.915 v1(113.509,82.848) ; v1(113.1,76.9) 113.111,76.911 113.814,76.911 C184.2@113.825,76.921 ; U38.1@113.525,80.78 v1(113.525,79.83) 114.175,79.83 ; R174.1@114,82.053 v1@114.712,82.053 ; U38.2@114.175,80.78 114.175,79.83 ; U38.3@114.825,80.78 v1(114.825,79.83) 114.175,79.83
  Bottom Layer w0.3: U40.8@104.975,79.1 v1(104.975,80.7) ; U40.5@106.925,79.1 v1(106.925,80.7) ; U40.4@107.575,79.1 v1(107.575,80.325) ; U40.2@108.875,79.1 v1(108.875,80.325)
  Bottom Layer w0.5: v1@101.551,87.507 U46.16@102.931,87.507 ; v1@101.551,88.777 U46.15@102.931,88.777 ; v1@101.551,92.587 U46.12@102.931,92.587 ; v1@101.551,95.127 U46.10@102.931,95.127 ; v1@101.589,93.859 U46.11@102.969,93.859 ; U46.9@102.968,96.4 102.969,96.399 104.349,96.399 v1(104.35,96.4) ; U45.15@102.969,77.579 v1@104.349,77.579 ; U45.9@102.969,85.199 v1@104.349,85.199 ; v1(104.45,95.25) U42.2@105.513,95.25 ; C196.1@104.95,88.55 v1(104.95,89.278) 104.977,89.278 105.102,89.403 105.166,89.403 105.65,89.887 105.65,90.053 C206.2@105.7,90.053 ; C204.1@106.2,76.3 v1(106.928,76.3) ; C198.1@106.95,88.55 v1(106.949,89.251) ; C202.1@107.025,91.653 v1(107.025,92.825) ; C201.1@107.75,88.55 v1(107.75,89.278) ; v1(108.6,91.175) C193.2@108.6,91.903 ; C192.1@110.2,90.878 v1(111.378,90.878) ; v1(114.4,83.475) JP2.1@114.4,84.45
  other v1: 104.35,77.58 114.713,82.054 104.35,85.2 101.55,87.506 101.55,88.776
GND_CAN1: C121.2 C124.1 C125.1 C127.1 C129.2 C132.1 J6.1 J6.3 R236.2 U18.9 U18.10 U18.11 U18.12 U18.15 U18.16 U20.5 U22.2 U22.8 U24.3 X32.1 | length 30.6
  Top Layer w0.5: U20.5@112.415,5.31 112.542,5.31 112.75,5.102 v1(112.75,4.55) ; v1(112.918,10.132) 112.926,10.124 113.891,10.124 C129.2@113.9,10.115 ; v1(113.569,11.604) 114.396,11.604 115.3,10.7 C124.1@115.3,10.1 ; U22.2@114.905,3.995 116.142,3.995 116.397,4.25 v1(116.45,4.25) ; U22.8@120.161,5.315 120.523,5.315 120.7,5.492 v1(120.7,6.05)
  Bottom Layer w0.25: v1(115.125,12.925) U24.3@115.95,12.925
  Bottom Layer w0.5: v1@113.569,11.604 U18.9@114.949,11.604 ; U18.16@114.75,2.77 115.104,2.77 115.279,2.595 115.279,2.241 115.67,1.85 v1(116.4,1.85) ; U18.15@114.943,3.992 116.142,3.992 116.399,4.25 v1(116.45,4.25) 116.515,4.315 C121.2@117.15,4.315 ; U18.11@114.95,9.065 114.905,9.11 113.5,9.11 113.25,9.36 R236.2@111.8,9.36 ; U18.10@114.95,10.39 113.27,10.39 113.012,10.132 v1(112.918,10.132) 112.875,10.09 111.975,10.09 111.8,9.915 R236.2@111.8,9.36 ; v1@116.367,7.833 116.354,7.819 116.338,7.835 113.55,7.835 112.69,8.695 112.175,8.695 111.8,9.07 R236.2@111.8,9.36 ; v1(118.35,2.1) C125.1@118.35,3.25 ; v1(118.65,1.45) C127.1@119.7,1.45 ; v1(120.7,6.05) 121.282,6.05 121.575,6.343 121.575,6.575 C132.1@121.8,6.8
  other v1: 116.4,7.8