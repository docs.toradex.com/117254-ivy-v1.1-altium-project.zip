# Altium PCB 46806005.~(2).PcbDoc (part 3 of 9)
Units mm, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 130 x 105 mm, 8 copper layers (Top Layer, P1-GND, L1-Signal, L2-Signal, L3-Signal, L4-Signal, P2-GND, Bottom Layer), stack 1.63 mm thick; 797 components, 496 nets, 2816 pads, 1210 vias.
Unrouted connection lines stored in the file: 1.

## Footprints (in the part's own frame and the unit in brackets; to place one, negate y for a bottom-side part, rotate by r counter-clockwise, add the part's x,y. Pads: shape width x height; smd on the part's side, far side on the other; paste and mask are expansions set on the pad) (continued)
RESNET-1206-4 [mm]
  rect 0.5x0.8 smd: 1(-1.2,-0.8) 2(-0.4,-0.8) 3(0.4,-0.8) 4(1.2,-0.8) 5(1.2,0.8) 6(0.4,0.8) 7(-0.4,0.8) 8(-1.2,0.8)
  silkscreen extent -1.75,-0.87 1.7,0.87, body extent -1.6,-0.8 1.6,0.8, height 0.57
RGZ0048B [mm] "48-VQFN (7x7) (RGZ) Exposed Pad with vias"
  oval 0.6x0.24 smd paste+0 mask+0.051: 1(-3.4,2.75) 2(-3.4,2.25) 3(-3.4,1.75) 4(-3.4,1.25) 5(-3.4,0.75) 6(-3.4,0.25) 7(-3.4,-0.25) 8(-3.4,-0.75) 9(-3.4,-1.25) 10(-3.4,-1.75) 11(-3.4,-2.25) 12(-3.4,-2.75) 25(3.4,-2.75) 26(3.4,-2.25) 27(3.4,-1.75) 28(3.4,-1.25) 29(3.4,-0.75) 30(3.4,-0.25) 31(3.4,0.25) 32(3.4,0.75) 33(3.4,1.25) 34(3.4,1.75) 35(3.4,2.25) 36(3.4,2.75)
  oval 0.24x0.6 smd paste+0 mask+0.051: 13(-2.75,-3.4) 14(-2.25,-3.4) 15(-1.75,-3.4) 16(-1.25,-3.4) 17(-0.75,-3.4) 18(-0.25,-3.4) 19(0.25,-3.4) 20(0.75,-3.4) 21(1.25,-3.4) 22(1.75,-3.4) 23(2.25,-3.4) 24(2.75,-3.4) 37(2.75,3.4) 38(2.25,3.4) 39(1.75,3.4) 40(1.25,3.4) 41(0.75,3.4) 42(0.25,3.4) 43(-0.25,3.4) 44(-0.75,3.4) 45(-1.25,3.4) 46(-1.75,3.4) 47(-2.25,3.4) 48(-2.75,3.4)
  rect 4.1x4.1 smd paste-2.037 mask+0.051: 49(0,0)
  silkscreen extent -4.07,-3.72 3.72,3.72, body extent -3.5,-3.5 3.5,3.5, height 1
SAMTEC_FTSH-105-01-L-DV-K-TR [mm]
  rrect30% 0.76x2.4 smd: 1(-2.54,-1.95) 2(-2.54,1.95) 3(-1.27,-1.95) 4(-1.27,1.95) 5(0,-1.95) 6(0,1.95) 7(1.27,-1.95) 8(1.27,1.95) 9(2.54,-1.95) 10(2.54,1.95)
  silkscreen extent -3.43,-4.04 3.43,3.43, body extent -3.17,-2.92 3.18,2.92, height 6.1
Short_040 [mm]
  rrect50% 1.1x1 smd paste-2539.97 mask-2539.97: 1(-0.85,0) 2(0.85,0)
  Top Layer pour cut-out: -0.635,-0.508 0.635,-0.508 0.635,0.508 -0.635,0.508
  Top Layer region: -1.143,-0.381 1.143,-0.381 1.143,0.381 -1.143,0.381
SIM8055611400A [mm] "SIM NANO PUSH PULL 6P, 1.35MM"
  rect 1x0.7 smd: C1(2.54,-5.795) C2(0,-5.795) C3(-2.54,-5.795) C6(0,5.795) C7(-2.54,5.795)
  rect 0.5x0.7 smd: C5(2.19,5.795) CD(2.89,5.795)
  round 0.7 hole 0.8 unplated: MH1(4.6,4.15)
  round 1.5 hole 1: MH2(-4.4,-4.15)
  rect 1x2 smd: MP1(5.3,0) MP2(-5.3,0)
  Top Layer keep-out region: 3.15,2.953 1.95,2.953 1.95,3.953 3.15,3.953
  Top Layer keep-out region: 0.603,2.95 -0.597,2.95 -0.597,3.95 0.603,3.95
  Top Layer keep-out region: -1.937,2.95 -3.137,2.95 -3.137,3.95 -1.937,3.95
  Top Layer keep-out region: 1.943,-2.95 3.143,-2.95 3.143,-3.95 1.943,-3.95
  Top Layer keep-out region: -0.597,-2.95 0.603,-2.95 0.603,-3.95 -0.597,-3.95
  Top Layer keep-out region: -3.137,-2.95 -1.937,-2.95 -1.937,-3.95 -3.137,-3.95
  Top Layer keep-out region: -3.572,2.425 3.578,2.425 3.578,-2.425 -3.572,-2.425
  silkscreen extent -4.77,-6.7 4.77,6.1, body extent -5.4,-6.1 5.4,6.1, height 1.35
SMAJ [mil] "Diode SMA J-lead / DO-214AC SMA"
  rect 60x58 smd: 1(-70,0) 2(70,0)
  silkscreen extent -111,-63 125,63, body extent -102,-51 102,51, height 95
SMAJ_TRANSIL [mm] "Diode SMA J-lead Transil / DO-214AC SMA"
  rect 1.4x1.64 smd: 1(-2.015,0) 2(2.015,0)
  silkscreen extent -2.92,-1.6 3.28,1.6, body extent -2.6,-1.3 2.6,1.3, height 2.4
SOD123_ALT [mm] "SOD-123; 2 Leads; Body 2.7 x 1.6 mm, (LxW)"
  rect 0.9x0.95 smd: 1(-1.575,0) 3(1.575,0)
  silkscreen extent -1.45,-0.85 1.45,0.85, body extent -1.85,-0.8 1.85,0.8, height 1.27
SOD923_DIO [mm] "Diode, SOD-923, CASE 514AA"
  rect 0.393x0.3 smd paste+0 mask+0: 1(-0.507,0) 2(0.507,0)
  Top Layer keep-out region: -0.15,-0.249 -0.15,0.249 0.15,0.249 0.15,-0.249
  body extent -0.53,-0.32 0.53,0.32, height 0.43
SOIC-8 [mil] "8-SOIC (0.154\", 3.90mm Width)"
  rect 75x25 smd: 1(-107.5,75) 2(-107.5,25) 3(-107.5,-25) 4(-107.5,-75) 5(107.5,-75) 6(107.5,-25) 7(107.5,25) 8(107.5,75)
  silkscreen extent -67,-100 35,110, body extent -118,-96 118,96, height 67
SOIC-16 [mm] "SOIC127P1030X265-16M_[SOIC-16W]_JEDEC_MS-013AA"
  rect 0.6x1.9 smd: 1(-4.445,-4.75) 2(-3.175,-4.75) 3(-1.905,-4.75) 4(-0.635,-4.75) 5(0.635,-4.75) 6(1.905,-4.75) 7(3.175,-4.75) 8(4.445,-4.75) 9(4.445,4.75) 10(3.175,4.75) 11(1.905,4.75) 12(0.635,4.75) 13(-0.635,4.75) 14(-1.905,4.75) 15(-3.175,4.75) 16(-4.445,4.75)
  silkscreen extent -5.42,-4.87 5.23,3.4, body extent -5.25,-5.32 5.25,5.32, height 2.66
SOP254P700X210-4N [mm] "SOP, 4-Leads, Body 3,70x4,55mm, Pitch 2,54mm, IPC Medium Density"
  oval 1.4x0.6 smd: 1(-3.225,1.27) 2(-3.225,-1.27) 3(3.225,-1.27) 4(3.225,1.27)
  silkscreen extent -3.3,-1.85 2.27,1.85, body extent -3.5,-1.85 3.5,1.85, height 2.3
"SOP-9 TP" [mm] "SOIC, 8-Leads, Body 5,0x4,0mm (max), Pitch 1,27mm, IPC Medium Density"
  oval 2x0.6 smd: 1(-2.5,1.905) 2(-2.5,0.635) 3(-2.5,-0.635) 4(-2.5,-1.905) 5(2.5,-1.905) 6(2.5,-0.635) 7(2.5,0.635) 8(2.5,1.905)
  rect 2.3x3.2 smd: 9(0,0)
  silkscreen extent -2.52,-2.5 0.9,2.88, body extent -3,-2.45 3,2.45, height 2.05
"SOP-9 TP_ALT" [mm] "SOIC, 8-Leads, Body 5,0x4,0mm (max), Pitch 1,27mm, IPC Medium Density"
  rect 1.505x0.802 smd: 1(-2.5,1.905) 2(-2.5,0.635) 3(-2.5,-0.635) 4(-2.5,-1.905) 5(2.5,-1.905) 6(2.5,-0.635) 7(2.5,0.635) 8(2.5,1.905)
  rect 2.613x3.502 smd: 9(0,0)
  silkscreen extent -2.52,-2.5 0.9,2.88, body extent -3,-2.45 3,2.45, height 1.45
SOT23 [mm]
  rrect50% 0.85x1 smd: 1(-0.95,-1.2) 2(0.95,-1.2) 3(0,1.2)
  silkscreen extent -1.9,-1.32 1.28,1.2, body extent -1.45,-1.4 1.45,1.4, height 1.3
SOT23-5 [mil] "SOT23-5, JEDEC MO-178 variation AA, 5-lead SMD package, most material condition"
  rect 30x45 smd: 1(-40,-50) 2(0,-50) 3(40,-50) 4(40,50) 5(-40,50)
  silkscreen extent -89,-87 65,87, body extent -57,-55 57,55, height 57
sot23-6 [mm]
  rrect25% 0.58x1.21 smd: 1(-0.95,-1.255) 2(0,-1.255) 3(0.95,-1.255) 4(0.95,1.255) 5(0,1.255) 6(-0.95,1.255)
  silkscreen extent -1.73,-1.37 1.56,0.8, body extent -1.45,-1.4 1.45,1.4, height 1.45
SOT23-6 [mm]
  rrect25% 0.58x1.21 smd: 1(-0.95,-1.255) 2(0,-1.255) 3(0.95,-1.255) 4(0.95,1.255) 5(0,1.255) 6(-0.95,1.255)
  silkscreen extent -1.73,-1.37 1.56,0.8, body extent -1.45,-1.4 1.45,1.4, height 1.45
SOT23_M [mm]
  rrect50% 1.6x0.6 smd: 1(-1.1,0.95) 2(-1.1,-0.95) 3(1.1,0)
  silkscreen extent -1.22,-1.5 0.7,1.93, body extent -1.4,-1.45 1.4,1.45, height 1.3
SOT23_N [mm] "SOT23, 3-Leads, Body 2.9x1.3mm, Pitch 0.95mm, Lead Span 2.3mm, IPC Medium Density"
  rrect50% 1.3x0.6 smd: 1(-1.05,0.95) 2(-1.05,-0.95) 3(1.05,0)
  silkscreen extent -1.18,-1.5 0.7,1.92, body extent -1.4,-1.45 1.4,1.45, height 1.3
SOT353-5N [mm] "SOT353, SC70, 5-Leads, Body 2x1.3mm, Pitch 0.65mm, Lead Span 2.1mm, IPC Medium Density"
  rrect50% 0.85x0.4 smd: 1(-0.95,0.65) 2(-0.95,0) 3(-0.95,-0.65) 4(0.95,-0.65) 5(0.95,0.65)
  silkscreen extent -1.07,-1.1 0.18,1.32, body extent -1.2,-1.1 1.2,1.1, height 1.1
SOT563 [mm]
  rect 0.45x0.3 smd: 1(-0.675,0.5) 2(-0.675,0) 3(-0.675,-0.5) 4(0.675,-0.5) 5(0.675,0) 6(0.675,0.5)
  silkscreen extent -1.18,-0.66 0.24,0.66, body extent -0.81,-0.8 0.81,0.8, height 0.59
SOT-323 [mm] "SOT-323/SC-70; 3 Leads; Body 2.2 x 2.2 mm, inc. leads (LxW max)"
  rect 0.8x1.05 smd: 1(-0.65,-1.025) 2(0.65,-1.025) 3(0,1.025)
  silkscreen extent -1.52,-1.17 1.1,0.89, body extent -1.1,-1.12 1.1,1.12, height 1.1
SW_TL3340 [mm] "SWITCH TACTILE SPST-NO SMD"
  rect 0.4x1.8 smd paste-1 mask+0: 1(-1.225,0.9) 3(1.225,0.9)
  rect 0.6x1.8 smd: 2(0,0.9)
  rect 1.3x0.9 smd: SH1(-1.85,-1.05) SH2(1.85,-1.05)
  round 0.9 hole 0.9 unplated mask+0: ""(-2.125,0) ""(2.125,0)
  Top Layer region: 1.6,0.462 1.6,1.8 0.85,1.8 0.85,0 1.425,0 1.47,0.247 1.599,0.462 1.599,0.462
  Top Layer region: -1.6,0.462 -1.6,1.8 -0.85,1.8 -0.85,0 -1.425,0 -1.47,0.247 -1.599,0.462 -1.599,0.462
  Top Layer keep-out region: 1,-1.5 -1,-1.5 -1,-0.3 1,-0.3
  Top Layer keep-out lines w0.05: -1.85,0.55 -1.85,2 1.857,2 1.857,0.55
  silkscreen extent -2.25,-2.05 2.25,1.9, body extent -2.25,-2.05 2.25,1.62, height 3.3
"T_AMPHENOL_ GSB311231HR" [mm]
  round 1.1 hole 0.7: L1(-3.5,-1.35) L2(-1,-1.35) L3(1,-1.35) L4(3.5,-1.35) L5(4,0.15) L6(2,0.15) L7(0,0.15) L8(-2,0.15) L9(-4,0.15) U1(-3.5,1.85) U2(-1,1.85) U3(1,1.85) U4(3.5,1.85) U5(4,3.35) U6(2,3.35) U7(0,3.35) U8(-2,3.35) U9(-4,3.35)
  round 2.9 hole 2.3: S1(-6.57,-3.35) S2(-6.57,2.33) S3(6.57,2.33) S4(6.57,-3.35)
  silkscreen extent -6.8,-11.02 6.8,4.72, body extent -7.79,-15.13 7.79,4.57, height 16.13
T_KEYSTONE_3000 [mm] "Battery Holder"
  rrect70% 12x12.3 smd paste-11: 1(0,-0.15)
  rrect10% 3.2x3.9 smd: 2(-8.17,0) 2(8.17,0)
  silkscreen extent -6.63,-6.75 6.63,6.3, body extent -9.47,-6.72 9.47,5.34, height 3.16
TestPoint_1#1 [mm]
  round 1.3 hole 0.8: 1(0,0)
  silkscreen extent -0.9,-0.9 0.9,0.9
TestPoint_1#2 [mm] "Through hole 0.8/1.2mm with overlays on top/bot"
  round 1.2 hole 0.8: 1(0,0)
  silkscreen extent -0.85,-0.85 0.85,0.85
TestPoint_3 [mm]
  round 1.25 smd paste-1.25: 1(0,0)
TLP241A_TP1 [mm] "TOSHIBA TLP241A_TP1"
  rect 1.6x1.5 smd paste+0 mask+0: 1(-4.35,1.27) 2(-4.35,-1.27) 3(4.35,-1.27) 4(4.35,1.27)
  silkscreen extent -4.85,-2.54 3.45,2.55, body extent -5,-2.41 5,2.41, height 4.24
TSOT-23-8_TEX [mil] "SOT-23-8, TSOT-23-8, Texas DDF0008A"
  rrect50% 39.5x18 smd paste-1.97 mask+3.94: 1(-52.25,38.39) 2(-52.25,12.8) 3(-52.25,-12.79) 4(-52.25,-38.38) 5(52.25,-38.38) 6(52.25,-12.79) 7(52.25,12.8) 8(52.25,38.39)
  silkscreen extent -58,-63 38,67, body extent -55,-57 55,57, height 39
TSSO3x5-G8/X.35 [mm] "TSSOP-8P065 Shrink Small Outline; 8 Leads; Body Width 3 mm; Pitch 0.65 mm"
  rrect25% 0.4x1.42 smd: 1(-0.975,-1.77) 2(-0.325,-1.77) 3(0.325,-1.77) 4(0.975,-1.77) 5(0.975,1.77) 6(0.325,1.77) 7(-0.325,1.77) 8(-0.975,1.77)
  silkscreen extent -1.65,-2.11 1.52,0.8, body extent -1.47,-2 1.47,2, height 1.3
TSSOP16 [mm]
  rect 1.65x0.3 smd: 1(-3.25,2.275) 2(-3.25,1.625) 3(-3.25,0.975) 4(-3.25,0.325) 5(-3.25,-0.325) 6(-3.25,-0.975) 7(-3.25,-1.625) 8(-3.25,-2.275) 9(3.25,-2.275) 10(3.25,-1.625) 11(3.25,-0.975) 12(3.25,-0.325) 13(3.25,0.325) 14(3.25,0.975) 15(3.25,1.625) 16(3.25,2.275)
  silkscreen extent -2.89,-2.55 1.55,2.97, body extent -3.3,-2.55 3.3,2.55, height 1.2
UQFN-24 [mm]
  rect 0.7x0.2 smd paste-0.337 mask+0.05: 1(-0.85,1.8) 2(-0.85,1.4) 9(-0.85,-1.4) 10(-0.85,-1.8) 13(0.85,-1.8) 14(0.85,-1.4) 21(0.85,1.4) 22(0.85,1.8)
  rect 1x0.2 smd paste-0.487 mask+0.05: 3(-0.7,1) 4(-0.7,0.6) 5(-0.7,0.2) 6(-0.7,-0.2) 7(-0.7,-0.6) 8(-0.7,-1) 15(0.7,-1) 16(0.7,-0.6) 17(0.7,-0.2) 18(0.7,0.2) 19(0.7,0.6) 20(0.7,1)
  rect 0.2x0.75 smd paste-0.362 mask+0.05: 11(-0.2,-1.825) 12(0.2,-1.825) 23(0.2,1.825) 24(-0.2,1.825)
  silkscreen extent -1.88,-2.25 1.36,2.25, body extent -1,-2 1,2, height 0.55
WEIDMULLER_1728700000 [mm] "TERM BLOCK HDR 20POS 90DEG 3.5MM"
  rrect50% 1.8x1.8 hole 1.3 paste-2539.97: 1(-15.75,0.55)
  round 1.8 hole 1.3 paste-2539.97: 2(-15.75,3.05) 3(-12.25,0.55) 4(-12.25,3.05) 5(-8.75,0.55) 6(-8.75,3.05) 7(-5.25,0.55) 8(-5.25,3.05) 9(-1.75,0.55) 10(-1.75,3.05) 11(1.75,0.55) 12(1.75,3.05) 13(5.25,0.55) 14(5.25,3.05) 15(8.75,0.55) 16(8.75,3.05) 17(12.25,0.55) 18(12.25,3.05) 19(15.75,0.55) 20(15.75,3.05)
  round 0 hole 2.4 unplated paste-2539.97 mask-1.41: 21(-19.25,-3.05) 22(19.25,-3.05)
  silkscreen extent -21.68,-7.65 21.08,4.28, body extent -21,-10.05 21,4.15, height 10.5
WSON-8(2.1x2.1)_PAD [mm] "8-WFDFN Exposed Pad, 8-WSON (2x2), DSG0008A_TEX"
  rect 0.5x0.25 smd paste+0 mask+0: 1(-0.95,0.75) 2(-0.95,0.25) 3(-0.95,-0.25) 4(-0.95,-0.75) 5(0.95,-0.75) 6(0.95,-0.25) 7(0.95,0.25) 8(0.95,0.75)
  rect 0.9x1.6 smd paste-0.45 mask+0: 9(0,0)
  silkscreen extent -1.1,-1.15 1.07,1.4, body extent -1,-1 1,1, height 0.77
WURTH_9774025243R [mm] "SMT Steel Spacer with internal Thread M2, height 2.5mm"
  round 0 hole 3 unplated: 1(0,0)
  Top Layer circle w1: c0,0 r2.15
  Top Layer keep-out circle w0.05: c0,0 r2.85
  Bottom Layer keep-out circle w0.05: c0,0 r1.7
  body extent -2.17,-2.17 2.18,2.17, height 2.5
XTAL_CX3225 [mm] "KYOCERA"
  rect 1.3x1.05 smd mask+0.08: 1(-1.15,-0.925) 2(1.15,-0.925) 3(1.15,0.925) 4(-1.15,0.925)
  silkscreen extent -1.98,-1.63 0.2,1.47, body extent -1.6,-1.25 1.6,1.25, height 1.05

## Part data
C2 C102 C109 C163 C257: "CAP CER 1000PF 2KV X7R 1206", Mfr="Johanson Dielectrics Inc.", MfrNo=202R18W102KV4E, Supplier Part Number 1=709-1036-1-ND
C3 C67 C68 C69 C80: "(-55 to 125 DegC) CAP FEEDTHRU 1UF 20% 100V 1206 6A", Mfr="TDK Corporation", MfrNo=YFF31HC2A105MT000N, Supplier Part Number 1=445-16151-1-ND
C4 C5 C6 C7 C8 C12 C17 C21 C39 C58 C66 C86 C88 C89 C91 C123 C124 C158 C159 C165 C166 C174 C176 C180 C181 C239 C241 C242 C243: library part 2404-Cap-0402-22uF/6.3V, "(-55 to 85 DegC) CAP CER 22UF 6.3V 20% X5R 0402", Mfr=Murata, MfrNo=GRM155R60J226ME11D, Supplier Part Number 1=C415703
C9 C10 C11 C13 C14 C15 C16 C25 C28 C30 C32 C36 C38 C44 C50 C62 C64 C82 C97 C100 C101 C103 C106 C108 C111 C114 C117 C118 C119 C120 C121 C122 C127 C128 C129 C130 C145 C147 C148 C150 C151 C152 C153 C154 C155 C157 C160 C167 C170 C171 C172 C173 C175 C182 C185 C186 C187 C188 C193 C194 C195 C196 C197 C198 C199 C201 C203 C204 C205 C206 C207 C208 C209 C210 C211 C213 C215 C216 C218 C219 C220 C221 C222 C223 C225 C227 C228 C229 C230 C231 C232 C244 C245 C246 C247 C248 C249 C250 C251 C252 C254 C256 C258 C259 C260: library part 1566-Cap-0402-100nF/50V, "(-55 to 125 DegC AEC) Cap Ceramic 0.1uF 50V X7R 10% 0402", Mfr=Murata, MfrNo=GRT155R71H104KE01D, Supplier Part Number 1=490-GRT155R71H104KE01DCT-ND
C18 C24 C29 C31 C33 C35 C37 C40 C42 C45 C46 C47 C51 C52 C53 C56 C57 C63 C65: library part 1149-Cap-0402-10nF/50V, "Cap Ceramic 10nF 50V X7R 10% 0402", Mfr=Yageo, MfrNo=CC0402KRX7R9BB103, Supplier Part Number 1=311-1349-2-ND
C19 C26 C43 C134 C136 C137 C138 C140 C141 C144 C146 C149 C161 C162: "Cap Ceramic 1uF 6.3V X5R 20% SMD 0402 85C T/R", Mfr=Samsung, MfrNo=CL05A105MQ5NNNC, Supplier Part Number 1=1276-1235-1-ND
C20 C27 C34 C41 C48 C49 C54 C55 C59 C60: "CAP CER 1000PF 50V 5% NP0 0402", Mfr="Samsung Electro-Mechanics America, Inc", MfrNo=CL05C102JB5NNNC, Supplier Part Number 1=1276-1635-1-ND
C22 C23: "(-55 to 125 DegC AEC) CAP CER 20PF 5% 50V C0G/NPO 0402", Mfr=Samsung, MfrNo=CL05C200JB51PNC, Supplier Part Number 1=1276-6601-1-ND
C61 C71 C74 C92 C94 C95 C96 C98 C99 C104 C115 C116 C125 C126 C191 C192 C200 C202 C212 C214 C217 C224 C226 C233 C240: "(-55 to 85 DegC) CAP CER 22uF 16V X5R 0805", Mfr=Samsung, MfrNo=CL21A226MOQNNNE, Supplier Part Number 1=1276-2909-1-ND
C70 C72 C75 C76 C78 C79: library part 1873-Cap-1206-2.2uF/100V, "(-55 to 125 DegC) CAP CER 2.2UF 100V 10% X7R 1206", Mfr=Yageo, Supplier Part Number 1=311-3450-1-ND
C73 C77: library part 1607-Cap-1206-10uF/50V, "(-55 to 85 DegC) CAP CER 10UF 50V 10% X5R 1210", Mfr=Samsung, MfrNo=CL31A106KBHNNNE, Supplier Part Number 1=1276-2876-1-ND
C81: "(-55 to 125 DegC) CAP CER 3600PF 50V C0G/NP0 0603", Mfr=Murata, MfrNo=GRM1885C1H362JA01D, Supplier Part Number 1=490-6386-1-ND
C83 C90 C183 C184 C189 C190: "(-55 to 125 Degc AEC) CAP CER 100PF 50V 5% NPO 0402", Mfr=Murata, MfrNo=GCM1555C1H101JA16D, Supplier Part Number 1=490-10669-1-ND
C84: "Cap 0603 DNP"
C85 C93: "(-55 to 125 DegC) CAP CER 2.2nF 100V 10% X7R 0603", Mfr=KEMET, MfrNo=C0603C222K1RACTU, Supplier Part Number 1=399-C0603C222K1RAC7867CT-ND
C87: "(-55 to 125 DegC AEC) Cap Ceramic 0.1uF 50V X7R 10% 0402", Mfr=Murata, MfrNo=GRT155R71H104KE01D, Supplier Part Number 1=490-GRT155R71H104KE01DCT-ND
C107: "(-55 to 85 DegC) CAP CER 4.7UF 10V 20% X5R 0603", Mfr=Samsung, MfrNo=CL10A475KP8NNNC, Supplier Part Number 1=1276-1044-1-ND
C131 C132: "CAP CER 4700PF 50V 5% NP0 0603", Mfr="Murata Electronics North America", MfrNo=GRM1885C1H472JA01D, Supplier Part Number 1=490-9669-1-ND
C133 C135 C143 C164: "(-55 to 85 DegC) CAP CER 10UF 6.3V 20% X5R 0402", Mfr=Murata, MfrNo=GRM155R60J106ME44D, Supplier Part Number 1=490-13811-2-ND
C139 C142: "CAP CER 18PF 50V 5% NP0 0402", Mfr="Samsung Electro-Mechanics America, Inc", MfrNo=CL05C180JB5NNNC, Supplier Part Number 1=1276-1140-1-ND
C156 C177 C178 C179: "(-55 - 125 DegC) CAP CER 30PF 50V C0G/NP0 0603", Mfr="Kyocera AVX", MfrNo=06035A300JAT2A\4K, Supplier Part Number 1=478-7917-1-ND
C168 C169 C255: library part 2241-Cap-6.6x6.6-330uF/6.3V, "(-55 to 105 DegC) CAP ALUM POLY 33UF 6.3V 20% SMD 10mohm 6.6x6.6x6.1mm Ir:3.9A (100kHz)", Mfr="United Chemi-Con", MfrNo=APXF6R3ARA331MF61G, Supplier Part Number 1=565-APXF6R3ARA331MF61GCT-ND
C234: "(-55 to 125 DegC) CAP CER 0.047UF 50V X7R 0603", Mfr="TDK Corporation", MfrNo=C1608X7R1H473K080AA, Supplier Part Number 1=445-1313-1-ND
C235 C236 C237 C238: "(-55 to 85 DegC) CAP CER 1UF 16V 10% X7R 0603", Mfr=Samsung, MfrNo=CL10B334KO8NNNC, Supplier Part Number 1=1276-2048-1-ND
C253: library part 1314-Cap-0805-22uF/16V, "(-55 to 85 DegC) CAP CER 22uF 16V X5R 0805", Mfr=Samsung, MfrNo=CL21A226MOQNNNE, Supplier Part Number 1=1276-2909-1-ND
D1 D14 D15 D16 D17 D23 D24 D25 D26 D27 D28: library part 0581-SMAJ33CA, "(-55 to 150 DegC) TVS DIODE 33VWM Vbrm:36.7V Vcl:53.3V 400W SMA", Mfr="Vishay Semiconductor Diodes Division", MfrNo=SMAJ33CA-E3/5A, Supplier Part Number 1=SMAJ33CA-E3/5AGICT-ND
D2: library part 1164-SK510A, "(-55 to 150 DegC) DIODE SCHOTTKY 5A 100V DO-214AC SMA 850mV@5A", Mfr=MCC, MfrNo=SK510A-LTP, Supplier Part Number 1=SK510A-LTPMSCT-ND
D3: library part 2201-SDT15H50P5-13, "(-55 to 150 DegC) DIODE SCHOTTKY 15A 50V Vf:0.3V@1.5A 0.47V@15A SMA", Mfr=Diodes, Supplier Part Number 1=31-SDT15H50P5-13CT-ND
D4 D6 D10 D11 D12 D13 D18 D20 D21 D22: library part "0333-LED Green 0603", "(-40 to 85 DegC) LED GREEN 0603 50mcd", Mfr=Kingbright, MfrNo=APT1608CGCK, Supplier Part Number 1=754-1116-1-ND
D5 D7 D8 D9: library part "2349-LED RGB 4SMD", "(-40 to 85 DegC) LED RGB 2.1mm x 1.9mm x 1mm 4SMD vf=2V Red, 2.6V Green, 2.7V Blue", Mfr=Broadcom, Supplier Part Number 1=516-ASMB-LTC3-0D335CT-ND
D19: library part 0859-BAV199, "(-65 to 150 DegC) DIODE ARRAY SeriesConnection 85V 140MA SOT23-3 Low Leakage Ilk=5nA", Mfr="Diodes Incorporated", MfrNo=BAV199-7-F, Supplier Part Number 1=BAV199-FDICT-ND
D29 D30: library part 1159-1N4148W, "(-55 to 150 DegC) DIODE GEN PURP 100V 300MA SOD123", Mfr=Diodes, MfrNo=1N4148W-7-F, Supplier Part Number 1=1N4148W-FDICT-ND
D31 D32 D33 D34: library part 1655-D5V0L1B2S9-7, "(-65 to 155 DegC) TVS DIODE Vwm:5V Vcl:14V@6A SOD-923", Mfr=Diodes, Supplier Part Number 1=D5V0L1B2S9-7DICT-ND
F1: library part "2235-Fuse 5A Slow 125V", "(-55 to 125 DegC AEC) FUSE BOARD MOUNT 5A SLOW 125VAC/VDC", Mfr=Bel, MfrNo=0680L5000-05, Supplier Part Number 1=530-0680L5000-05
FID1 FID2 FID3 FID4 FID5 FID6: library part 0000-Fiducial-round
H1 H2 H3 H4 H5: library part 000-Hole-125mil
J1: "Header, 6-Pin"
J2: library part "2240-CONN-HDR 8x2 16POS 1.27MM", "(-40 to 105 DegC) CONN HEADER VERT 8x2 16POS Shroud Latch Lock/Eject Hooks, Short 1.27MM SMT", Mfr="CNC Tech", Supplier Part Number 1=1175-2193-ND
J3: library part "1195-Conn-Molex 2-POS R/A", "(-40 to 105 DegC) TERM BLOCK HDR 2POS 90DEG RA 3.5MM 8A ScrewFlange Black", Mfr=Molex, Supplier Part Number 1=WM23188-ND
J4: library part 1660-Conn-USB-Type-C, "(-40 to 85 DegC) Conn USB TYPE C RA, 24 (16+8 Dummy) Position, SMT/TH", Mfr="Global Connector Technology", Supplier Part Number 1=2073-USB4105-GF-A-120CT-ND
J5 J6: library part 2319-Conn-Hdr-2x10pin-RA-Flanges, "(-50 to 100 DegC) TERM BLOCK HDR 20POS 90DEG 3.5MM", Mfr=Weidmuller, Supplier Part Number 1=281-1826-ND
J7 J10: library part 1380-Conn-RJ45-GBe, "(-40 to 85 DegC) CONN MAGJACK 1PORT 1000 BASE-T Isolated Taps", Mfr=Pulse, Supplier Part Number 1=1840-1005-ND
J8: library part 1390-Conn-MiniPCIe, "(-55 to 85 DegC) CONN MINI EXPRESS CARD 52POS SMD", Mfr="TE Connectivity", Supplier Part Number 1=A142273CT-ND
J9: library part 1401-Conn-NanoSIM, "(-40 to 85 DegC) CONN SIM NANO PUSH PULL 6P, 1.35mm height", Mfr="Global Connector Technology", Supplier Part Number 1=2073-SIM8055-6-1-14-00-ACT-ND
J11: library part 1391-Conn-MiniPCIe-Latch, "(-55 to 85 DegC) CONN MINI EXPRESS CARD LATCH SMD", Mfr="TE Connectivity", Supplier Part Number 1=A125031CT-ND
J12: library part 1776-Conn-MicroSD, "(-40 to 85 DegC) CONN MICRO SD CARD PUSH-PUSH R/A, OPEN", Mfr="Global Connector Technology", Supplier Part Number 1=2073-MEM2052-00-195-00-ACT-ND
J13: library part "1486-Conn-Header 5X2 SMT Vert", "(-55 to 125 DegC) CONN HEADER VERT 10POS 2x5 1.27MM SMT Gold Shroud", Mfr=Samtec, MfrNo=FTSH-105-01-L-DV-K-TR, Supplier Part Number 1=SAM13165CT-ND
J14 J18 J19 J20 J21: library part "2350-CONN HEADER VERT 2POS 1.27MM", "(-40 to 105 DegC) CONN HEADER VERT 2POS 1.27MM GOLD", Mfr=Sullins, Supplier Part Number 1=S9014E-02-ND
J15: library part 2373-F314-1A7H1-11034, "(-40 to 105 DegC) CONN FFC SIDE 34POS 0.5MM VERT", Mfr="Amphenol ICC / FCI", Supplier Part Number 1=609-F314-1A7H1-11034CT-ND
J16: library part 1820-Conn-USB3-2x-RA, "(-40 to 85 DegC) Conn USB 3.1 Type A R/A TH", Mfr="Amphenol Commercial", Supplier Part Number 1=GSB4112312HR-ND
J17: "Header, 3-Pin"
JP1 JP2: library part 000-Jumper-Short, "Jumper Wire"
L1 L3 L4 L5 L6 L7 L15 L16 L17 L24 L25 L26 L27 L28 L29 L30 L31 L32 L33 L34 L40: "(-55 to 125 DegC) FERRITE BEAD 330 OHM 0603 1.7A 80mohm, typ 48mohm", Mfr="TDK Corporation", MfrNo=MPZ1608S331ATA00, Supplier Part Number 1=445-5221-1-ND
L2 L8 L9 L10: "(-55 to 125 DegC AEC) FERRITE BEAD 600ohm 1206 2.5A 50mohm R@1A@150MHz:40.7ohm", Mfr="Wurth Electronics", MfrNo=78279221601, Supplier Part Number 1=732-78279221601CT-ND
L11: library part 1618-Ind-1210-1uH/5.5A, "(-40 to 125 DegC) FIXED IND 1UH I:5.5A Isat:6.5A 32mohm max 26mohm typ, full-shield SMD 1210", Mfr=Bourns, MfrNo=SRP3212-1R0M, Supplier Part Number 1=118-SRP3212-1R0MCT-ND
L12: library part 0598-Ind-10x6-60ohm/15A-Choke, "(-40 to 125 DegC) CMC Choke 15A  60OHM 10x6x4mm 15A 0.7mohm", Mfr="Laird-Signal Integrity Products", MfrNo=CM3421Y600R-10, Supplier Part Number 1=240-2501-1-ND
L13: library part 1638-Ind-7x7x3-4.7uH-5.5A, "(-55 to 125 DegC) FIXED IND 4.7UH FullShield 5.5A, 9A sat 40mohm 7.3x6.6x3.0mm", Mfr=Pulse, Supplier Part Number 1=553-BMRA000606304R7MA1CT-ND
L14: library part 1872-Ind-12x12x8-15uH-5A, "(-40 to 125 DegC) FIXED IND 15UH, 5A, 9.6A sat, 25mohm FullShield 12.5x12.5x8mm", Mfr="Eaton Cooper", Supplier Part Number 1=513-1040-1-ND
L18: library part 0277-Ind-2x1.2-90ohm/0.4A-Choke, "INDUCTOR COMMON MODE 90 OHM 0.4A 0.3ohm", Mfr="Bourns Inc.", MfrNo=SRF2012-900YA, Supplier Part Number 1=SRF2012-900YACT-ND
L35 L36 L37 L38 L39: library part 1371-Ind-0.8x0.6-12ohm/0.1A-Choke, "(-40 to 85 DegC) Ind CMC Choke 12 Ohm 0.1A 1ohm 0.85x0.65x0.5mm", Mfr=Panasonic, MfrNo=EXC-14CH120U, Supplier Part Number 1=P19438CT-ND
LBL1: library part 000-Label-10x10mm, "Label for serial number 10x10mm"
LBL2: library part 000-Label-0.25x0.9IN, "Label for Toradex serial number label 0.25x0.9 inch"
LP1: library part "2302-Lightpipe Lumex LPF-S014331S", "Lightpipe R/A for 1210 size LEDs. 3.2mm x 1.8mm lens size. Board mount, press fit.", Mfr=Lumex, Supplier Part Number 1=67-1860-ND
M1: library part 1140-Conn-Toradex-Verdin, "(-55 to 85 DegC) CONN DDR4 SODIMM 260P 5.2H STD", Mfr="TE Connectivity", Supplier Part Number 1=A141326CT-ND
ME1 ME2: library part 1412-Post-M2-7mm, "(-55 to 155 DegC) ROUND STANDOFF M2X0.4 STEEL 7MM for Verdin", Mfr="Wurth Electronics", Supplier Part Number 1=732-7107-2-ND
ME3 ME4: library part 1141-Post-M2-2.5mm, "(-55 to 155 DegC) ROUND STANDOFF M2X0.4 STEEL 2.5MM for Verdin", Mfr="Wurth Electronics", Supplier Part Number 1=732-7079-1-ND
PR1 PR2 PR3 PR4: library part 1078-PhotoRelay-TLP241A, "(-40 to 85 DegC) SSR RELAY SPST-NO 2A 0-40V 90mOhm typ 5x12.5mm", Mfr=Toshiba, MfrNo=TLP241A(TP1,F, Supplier Part Number 1=TLP241A(TP1FCT-ND
PTC1 PTC2 PTC3 PTC4 PTC5 PTC6 PTC7 PTC8: library part 1423-PTC-0.1A-60V-1812, "(-40 to 85 DegC) PTC Ih:0.1A, It:0.3A, 60V, 1812, 1.6-15ohm", Mfr=Bel, MfrNo=0ZCG0010FF2C, Supplier Part Number 1=507-1754-1-ND
Q1 Q2 Q3 Q4 Q9 Q10 Q11 Q14 Q15: library part 1146-NTZD3154NT1G, "(-55 to 150 DegC) MOSFET 2N-CH (dual) 20V 0.54A SOT-563 1.6x1.6mm Vth:1V Ron typ:400m@4.5V, 500m@2.5V, 700m@1.8V", Mfr="ON Semiconductor", MfrNo=NTZD3154NT1G, Supplier Part Number 1=NTZD3154NT1GOSCT-ND
Q5 Q6 Q7 Q8 Q13: library part 0761-FDV301N, "(-55 to 155 DegC) MOSFET N-CH 25V 220MA SOT-23 Vth:1.1V Ron typ:4ohm@3V Vgsm:8V", Mfr="Fairchild/ON Semiconductor", Supplier Part Number 1=FDV301NCT-ND
R1 R2 R123 R124 R125 R126 R190: "(-55 to 155 DegC AEC) RES 120 OHM 1% 1/16W 100ppm 0402", Mfr="Stackpole Electronics", MfrNo=RMCF0402FT120R, Supplier Part Number 1=RMCF0402FT120RCT-ND
R3 R55 R66 R131 R214: "(-55 to 155 DegC) RES SMD 1M OHM 5% 0.25W 10ppm 1206", Mfr="TE Connectivity", MfrNo=CRGCQ1206J1M0, Supplier Part Number 1=A130195CT-ND
R4 R36 R37 R51 R53 R54 R57 R58 R61 R62 R63 R106 R107 R108 R109 R133 R141 R146 R223: "(-55 to 155 DegC AEC) RES 27K OHM 1% 1/16W 100ppm 0402", Mfr="Stackpole Electronics", MfrNo=RMCF0402FT27K0, Supplier Part Number 1=RMCF0402FT27K0CT-ND
R5: "(-55 to 155 DegC) RES 0.0 OHM 1/10W JUMP 0603", Mfr=Samsung, MfrNo=RC1608J000CS, Supplier Part Number 1=1276-3510-1-ND
R6 R22 R29 R31 R59 R60 R132 R154 R157: "RES 0603"
R7 R88 R89 R176 R178 R188 R192: "(-55 to 155 DegC AEC) RES 1K OHM 1% 1/16W 100ppm 0402", Mfr="TE Connectivity", MfrNo=CRGCQ0402F1K0, Supplier Part Number 1=A129627CT-ND
R8 R94 R95 R96 R97 R138 R148: "(-55 to 155 DegC) RES SMD 60.4 OHM 1% 1/10W 0603", Mfr=Bourns, MfrNo=CR0603-FX-60R4ELF, Supplier Part Number 1=652-CR0603FX-60R4ELF
R9 R10 R12 R13 R15 R16 R17 R18 R24 R25 R26 R28 R30 R39 R67 R70 R71 R74 R75 R78 R79 R81 R149 R166 R167 R197 R198 R200 R202 R206 R210 R211 R212 R215 R221 R222 R225 R226 R227 R228 R263 R272 R273 R274 R275 R276: "(-55 to 155 DegC AEC) RES 10K OHM 1% 1/16W 100ppm 0402", Mfr="Stackpole Electronics", MfrNo=RMCF0402FT10K0, Supplier Part Number 1=RMCF0402FT10K0CT-ND
R11 R40 R68 R72 R73 R77 R80 R83 R85 R98 R99 R100 R101 R135 R140 R147 R151 R152 R153 R160 R161 R162 R163 R183 R184 R193 R194 R204 R205 R207 R208 R220 R224: "(-55 to 155 DegC AEC) RES 1.87K OHM 1% 1/16W 100ppm 0402", Mfr="Stackpole Electronics", MfrNo=RMCF0402FT1K87, Supplier Part Number 1=RMCF0402FT1K87CT-ND
R14 R27 R86 R87 R127 R177 R179 R187 R191: "(-55 to 155 DegC) RES 100K OHM 1/16W 1% 0402 SMD", Mfr=Yageo, MfrNo=RC0402FR-07100KL, Supplier Part Number 1=311-100KLRCT-ND
R19 R20: "(-55 to 155 DegC) RES 100 OHM 1/10W 1% 0603", Mfr=Yageo, MfrNo=RC0603FR-07100RL, Supplier Part Number 1=311-100HRCT-ND
R21: "(-55 to 155 DegC) RES 6.04K OHM 1/10W 1% 0402 SMD", Mfr=Panasonic, MfrNo=ERJ-2RKF6041X, Supplier Part Number 1=P6.04KLCT-ND
R23 R92 R93 R119 R142 R143 R144 R145 R209 R217 R218 R219 R229 R230 R231 R232: "RES 0.0 OHM 1/10W JUMP 0603", Mfr=Samsung, MfrNo=RC1608J000CS, Supplier Part Number 1=1276-3510-1-ND
R32 R48 R134 R182: "(-55 to 155 DegC) RES SMD 200K 1% 1/10W 0603 100ppm", Mfr="Stackpole Electronics", MfrNo=RMCF0603FT200K, Supplier Part Number 1=RMCF0603FT200KCT-ND
R33 R34 R42 R45 R46 R84 R174 R175: "(-55 to 155 DegC AEC) RES 86.6K OHM 1% 1/16W 100ppm 0402", Mfr="Stackpole Electronics", MfrNo=RMCF0402FT86K6, Supplier Part Number 1=RMCF0402FT86K6CT-ND
R35 R38 R52 R56 R121 R129 R139 R150 R185: "(-55 to 155 DegC AEC) RES 12K OHM 1% 1/16W 100ppm 0402", Mfr="Stackpole Electronics", MfrNo=RMCF0402FT12K0, Supplier Part Number 1=RMCF0402FT12K0CT-ND
R41 R43: "(-55 to 155 DegC AEC) RES 6.49K OHM 1% 0.25W 0805 100ppm", Mfr="KOA Speer", MfrNo=RK73H2ATTD6491F, Supplier Part Number 1=2019-RK73H2ATTD6491FCT-ND
R44: "(-55 to 155 DegC AEC) RES SMD 560K 1% 1/10W 0603 100ppm", Mfr="Stackpole Electronics", MfrNo=RMCF0603FT560K, Supplier Part Number 1=RMCF0603FT560KCT-ND
R47 R49 R50 R69 R76 R82 R136 R137 R168 R169 R170 R171 R172 R173 R180 R181 R203 R264 R269 R270 R271: "(-55 to 155 DegC) RES 4.70K OHM 1/16W 1% 0402 100ppm", Mfr=Yageo, MfrNo=RC0402FR-074K7L, Supplier Part Number 1=311-4.7KLRCT-ND
R64: "(-55 to 155 DegC AEC) RES 887K OHM 1% 1/16W 100ppm 0402", Mfr="Stackpole Electronics", MfrNo=RMCF0402FT887K
R65 R155 R195 R196: "RES SMD 274 OHM 1% 1/10W 0603", Mfr=Yageo, MfrNo=RC0603FR-07274RL, Supplier Part Number 1=311-274HRCT-ND
R90 R91 R189 R233 R234 R235 R236 R237 R238 R239 R240 R241 R242 R243 R244 R245 R246 R247 R248 R249 R250 R251 R252 R253 R254 R255 R256 R257 R258 R259 R260 R261 R262: "(-55 to 155 DegC) RES 0.0 OHM 1/4W JUMPER 1206", Mfr=TE, MfrNo=1623693-1, Supplier Part Number 1=A106079CT-ND
R102 R103 R104 R105: "RES SMD 680 OHM 1% 1/10W 0603", Mfr=Yageo, MfrNo=RC0603FR-07680RL, Supplier Part Number 1=311-680HRCT-ND
R110 R111 R112 R113: "(-55 to 155 DegC) RES SMD 10 OHM 5% 2W Pulse 2512", Mfr=Bourns, MfrNo=CRM2512AJW-100ELF, Supplier Part Number 1=CRM2512AJW-100ELFCT-ND
R114 R118: "(-55 to 155 DegC) RES SMD 2.49K OHM 1% 1/16W 0402 100ppm", Mfr=Yageo, MfrNo=RC0402FR-072K49L, Supplier Part Number 1=311-2.49KLRCT-ND
R115 R120: "(-55 to 155 DegC) RES 5.76K OHM 1/16W 1% 0402 SMD", Mfr="Stackpole Electronics", MfrNo=RMCF0402FT5K76, Supplier Part Number 1=RMCF0402FT5K76CT-ND
R116 R117 R199 R201 R265 R266 R267 R268: "RES 0402"
R122: "(-55 to 155 DegC AEC) RES SMD 11K OHM 1% 1/16W 0402 100ppm 0402", Mfr=Yageo, MfrNo=AC0402FR-0711KL, Supplier Part Number 1=YAG3439CT-ND
R128 R156: "RES 47.0K OHM 1/10W 1% 0603 SMD", Mfr=Yageo, MfrNo=RC0603FR-0747KL, Supplier Part Number 1=311-47.0KHRCT-ND
R130: "(-55 to 155 DegC) RES 47.0K OHM 1/10W 1% 0603 SMD", Mfr=Yageo, MfrNo=RC0603FR-0747KL, Supplier Part Number 1=311-47.0KHRCT-ND
R158 R159: "RES SMD 100 OHM 0.01% 0.5W 1206 5ppm", Mfr="Stackpole Electronics", MfrNo=RNCF1206TKY100R, Supplier Part Number 1=RNCF1206TKY100RCT-ND
R164 R165 R186: "(-55 to 155 DegC) RES SMD 6.49K OHM 1% 1/16W 0402", Mfr=Yageo, MfrNo=RC0402FR-076K49L, Supplier Part Number 1=311-6.49KLRCT-ND
R213 R216: "RES SMD 6.8K OHM 1% 1/10W 0603", Mfr=Yageo, MfrNo=RC0603FR-076K8L, Supplier Part Number 1=311-6.80KHRCT-ND
RA1 RA2: "(-55 to 125 DegC) RES ARRAY 4 RES 10K 1% 200ppm 1206", Mfr=Yageo, MfrNo=TC164-FR-0710KL, Supplier Part Number 1=RAVF164DJT10K0CT-ND
RA6 RA7: "(-55 to 125 DegC) RES ARRAY 4 RES 10 kOHM 30 kOHM 1206", Mfr="Vishay Beyschlag", MfrNo=ACASA1002S3002P100, Supplier Part Number 1=749-1027-1-ND
S1 S2: library part "1659-Push Button", "(-35 to 85 DegC) SWITCH TACTILE SPST-NO 0.05A 12V PushButton", Mfr=E-Switch, Supplier Part Number 1=EG4627CT-ND
U1 U2 U15 U27 U28 U34 U36 U69 U70 U71: library part 1657-DT1240-04LP-7, "(-55 to 85 DegC) IC TVS DIODE 4ch Vrm:5.5V Vcl:11V@5.5A 10-UFDFN 0.5mm", Mfr=Diodes, Supplier Part Number 1=DT1240-04LP-7DICT-ND
U3: library part 1361-SLM9670, "(-40 to 105 DegC) IC Trusted Platform TPM SECURITY 32-VFQFN", Mfr=Infineon, Supplier Part Number 1=SLM9670AQ20FW1311XTMA1CT-ND
U5: library part 1679-M24C02-FMC6TG, "(-40 to 85 DegC) IC EEPROM 2KBIT (256B) 400KHZ 1.7-5.5V adr 0x50-57 2x3mm 8-UFDFN", Mfr=STMicroelectronics, Supplier Part Number 1=497-15747-1-ND
U6: library part 1877-MB85RS256TY, "(-40 to 125 DegC) IC FRAM Memory 1.8-3.6V 256Kbit 32x8KB SPI 33 MHz 8-SOIC", Mfr=Fujitsu, Supplier Part Number 1=865-1293-1-ND
U7: library part 1853-TMP1075DSGR, "(-55 to 125 DegC) IC Temp Sensor I2C 1.7-5.5V WSON8", Mfr="Texas Instruments", Supplier Part Number 1=296-TMP1075DSGRCT-ND
U8: library part 2096-CYUSB3304-68LTXI, "(-40 to 85 DegC) IC USB 3.0 HUB 4-PORT 68QFN", Mfr="Infineon Technologies", Supplier Part Number 1=448-CYUSB3304-68LTXI-ND
U9 U29 U30 U65: library part 1467-AP2132BMP-2.5, "(-40 to 85 DegC) IC REG LDO LINEAR POS ADJ 5V 2A 8SO", Mfr=Diodes, Supplier Part Number 1=AP2132BMP-2.5TRG1DICT-ND
U10: library part 1619-TPS62823, "(-40 to 125 DegC) IC  IC REG BUCK ADJ 2.2MHz Vin:2.4-5.5V Io:3A Sync 8-VFDFN 8VSON-HR", Mfr="Texas Instruments", Supplier Part Number 1=296-50425-1-ND
U11: library part 1362-AP64500SP-13, "(-40 to 85 DegC) IC REG BUCK ADJ Sync 5A Vin:3.8 to 40V 100-2200kHz FSS (spread spectrum) MaxDuty:100% SO-8EP", Mfr=Diodes, Supplier Part Number 1=31-AP64500SP-13CT-ND
U12: library part 2063-LM5013DDAR, "(-40 to 150 DegC) IC REG BUCK ADJ 3.5A 8-POWERSOIC 1MHz 100V", Mfr="Texas Instruments", Supplier Part Number 1=296-LM5013DDARCT-ND
U13: library part 1458-TUSB320LI, "(-40 to 85 DegC) IC USB TYPE-C CC LOGIC AND PORT Control 12-X2QFN", Mfr="Texas Instruments", Supplier Part Number 1=296-42544-1-ND
U14: library part 1469-BD2222G, "(-40 to 85 DegC) IC PWR SWITCH 2.8-5.5V EN-Active-High ENth:2.0V No-Discharge 89mohm typ ADJ 0.2-1.7A 6SSOP", Mfr=Rohm, MfrNo=BD2222G-GTR, Supplier Part Number 1=846-BD2222G-GTRCT-ND
U16 U48: library part 2540-SN74AXC8T245RJWR, "(-40 to 125 DegC) IC TRANSLATION TXRX 0.65-3.6V 24UQFN", Mfr="Texas Instruments", Supplier Part Number 1=595-SN74AXC8T245RJWR
U18 U19 U44 U46 U49 U53: library part 2065-UCC12040DVER, "(-40 to 125 DegC) IC Isolated DC DC Converter-Output 3.3V, 5V 140mA, 4.5V-5.5V Input", Mfr="Texas Instruments", Supplier Part Number 1=595-UCC12040DVER
U20 U21 U50 U51 U54 U55: library part 2198-ISO6721RBDR, "(-40 to 125 DegC) IC DGTL ISO GENERAL-PURPOSE, DUAL-CHANNEL, 1x In, 1x Out 1.71-5.5V", Mfr="Texas Instruments", Supplier Part Number 1=595-ISO6721RBDR
U22 U23: library part 1620-TCAN1044VDRQ1, "(-40 to 125 DegC) IC TXRX CAN FD 8MBPS Vio:1.8-5V Standby 8SOIC", Mfr="Texas Instruments", Supplier Part Number 1=296-TCAN1044VDRQ1CT-ND
U24 U25: library part 1564-ESDCAN06-2BWY, "(-55 to 175 DegC AEC) TVS DIODE CAN 2-ch 35V Vcl: 59Vmax, 8/20:3A, ESD:30KV air,30KV cont, 15pF, SOT323", Mfr=STMicroelectronics, Supplier Part Number 1=497-17304-1-ND
U26: library part 2076-DP83867ERGZR, "(-40 to 105 DegC) Eth Phy RGMII 1GBASE-T VQFN-48", Mfr="Texas Instruments", Supplier Part Number 1=595-DP83867ERGZR
U31 U47: library part 0972-PCA9306DCT, "(-40 to 85 DegC) IC TRANSLTR BIDIRECTIONAL I2C SM8", Mfr="Texas Instruments", MfrNo=PCA9306DCTR, Supplier Part Number 1=296-18509-1-ND
U32: library part 1467-AP2132BMP-2.5, "(-40 to 85 DegC) IC REG LDO LINEAR POS ADJ 5V 2A 8SO", Mfr=Diodes, MfrNo=AP2132BMP-2.5TRG1, Supplier Part Number 1=AP2132BMP-2.5TRG1DICT-ND
U33 U66 U67: library part 0740-TPD4E001, "(-40 to 125 DegC AEC) TVS DIODE 5.5VWM 16VC SOT-23-6", Mfr="Texas Instruments", MfrNo=TPD4E001QDBVRQ1, Supplier Part Number 1=296-39344-1-ND
U35 U64 U68: library part 1475-AP22653, "(-40 to 85 DegC) IC PWR SWITCH 3-5.5V EN-Active-High ENth:1.5V With-Discharge 65mohm typ ADJ 0.1-2.1A 6SSOP", Mfr=Diodes, Supplier Part Number 1=31-AP22653AW6-7CT-ND
U37 U38: library part 1870-TPS26614, "(-40 to 155 DegC) IC Current Loop Protector 50V TSOT-23-8", Mfr="Texas Instruments", Supplier Part Number 1=296-TPS26614DDFRCT-ND
U39 U40: library part 1414-ADS1119, "(-40 to 125 DegC) IC ADC 16BIT 4ch 1000SPS 16-TSSOP I2C Adr 0x40-0x4F IntRef SigmaDelta", Mfr="Texas Instruments", MfrNo=ADS1119IPWR, Supplier Part Number 1=296-50874-1-ND
U41 U42: library part 0619-AP2202K-ADJ, "(-40 to 125 DegC) IC REG LDO ADJ 0.15A SOT23-5 13.2V", Mfr="Diodes Incorporated", MfrNo=AP2202K-ADJTRG1, Supplier Part Number 1=AP2202K-ADJTRG1DICT-ND
U43 U45: library part 2064-ISO1644DWR, "(-40 to 125 DegC) DGTL ISO 5KV 5CH I2C 16SOIC", Mfr="Texas Instruments", Supplier Part Number 1=296-ISO1644DWRTR-ND
U52: library part 2071-SN65176BDR, "(-40 to 125 DegC) IC TXRX 5V RS485/422 8-SOIC", Mfr="Texas Instruments", Supplier Part Number 1=296-14636-2-ND
U56: library part 0156-ST3232BTR, "IC DRVR/RCVR RS232 LP 16-TSSOP", Mfr=ST, Supplier Part Number 1=497-6534-1-ND
U57 U58 U59: library part 2239-PESD15VL2BT,215, "(-65 to 150 DegC) TVS DIODE 2-CH 15VWM 44VC ESD:30KV TO236AB", Mfr=Nexperia, Supplier Part Number 1=1727-3813-1-ND
U60 U61: library part 0394-PSSI2021, "(-65 to 150 DegC AEC)  IC CURRENT SOURCE SOT353 75V 50uA-50mA", Mfr="Nexperia USA Inc.", MfrNo=PSSI2021SAY,115, Supplier Part Number 1=1727-4328-1-ND
U62 U63: library part 1170-Opto-TLP185GR, "OPTOISO 3.75KV TRANS 6-SO 4 LEAD TR:100-300%@5mA, 80V, 3.7x7mm", Mfr=Toshiba, MfrNo=TLP185(GR-TPL,SE, Supplier Part Number 1=TLP185(GR-TPLSECT-ND
X8 X13 X14 X20 X21 X22 X23 X24 X51 X52 X53 X55 X57 X80 X81: "TestPoint SMD"
XS1: library part 1028-Conn-BatHolder-1220, "(-40 to 105 DegC) Battery Holder Coin 12mm SMD 1216/1220/1225", Mfr="Keystone Electronics", MfrNo=3000, Supplier Part Number 1=36-3000-ND
Y1: "(-40 to 85 DegC) XTAL CRYSTAL 26.0000MHZ 12PF SMD +-15ppm +-10ppm 2.0x1.6mm", Mfr="Murata Electronics", MfrNo=XRCGB26M000F1SADR0, Supplier Part Number 1=490-XRCGB26M000F1SADR0TR-ND
Y2: "(-40 to 85 DegC) CRYSTAL 25.0MHZ 18PF SMD +-50ppm +-20ppm 3.2x2.5mm", Mfr="IQD Frequency Products", MfrNo=LFXTAL055299REEL, Supplier Part Number 1=1923-1305-1-ND

## Via types
v1: diameter 0.6, hole 0.3, Top Layer to Bottom Layer, tented both sides, 1145 vias
v2: diameter 0.6, hole 0.3, Top Layer to Bottom Layer, 65 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point)
1V0_ETH: C133.2 C134.2 C136.2 C138.2 C141.2 C145.2 C148.2 C151.2 C154.2 C166.2 R129.2 U26.6 U26.24 U26.31 U26.42 U30.6 X53.1 | length 17.4
  Top Layer w0.5: C154.2@43.775,26.503 44.353,26.503 44.6,26.75 v1(44.6,27.4) 43.779,27.4 C141.2@43.775,27.403 ; C136.2@46.7,19.95 C133.2@47.55,19.95 v1(48.25,19.95) C148.2@48.95,19.95 ; v1(48.236,28.157) 48.25,28.171 C138.2@48.25,28.9 ; v1@48.25,28.15 48.95,28.15 49.1,28.3 C151.2@49.1,28.9
  Bottom Layer w0.15: X53.1@62.4,18.05 R129.2@62.4,19.345 63.075,19.345 63.42,19 v1(65.75,19)
  Bottom Layer w0.2: U26.24@44.6,26.825 v1(44.6,27.4) ; v1(48.236,28.157) 48.243,28.15 48.243,27.482 U26.31@48.25,27.475 ; v1(48.25,19.95) U26.6@48.25,20.675 ; U26.42@51.4,24.325 52.125,24.325 v1(52.15,24.3)
  Bottom Layer w0.5: v1(65.75,19) C166.2@65.75,19.8 65.75,21.88 U30.6@65.77,21.9
1V8: C14.2 C16.2 C111.2 C135.2 C137.2 C140.2 C144.2 C147.2 C150.2 C153.2 C157.2 C160.2 C161.2 C162.2 C164.2 C215.2 C216.2 J2.6 L3.1 L4.2 L25.1 L29.1 L32.2 Q15.2 Q15.5 R4.1 R7.2 R56.2 R58.2 R61.2 R85.2 R115.2 R117.1 R120.2 R121.2 R133.1 R140.2 R147.2 R157.2 R183.2 R184.2 R215.1 R220.2 R221.2 R222.1 R224.2 R264.1 R265.1 R267.1 R269.1 R274.2 R275.2 R276.2 RA1.1 RA1.2 RA1.3 RA1.4 U5.1 U5.2 U5.3 U5.8 U7.5 U7.6 U7.7 U7.8 U16.24 U26.13 U26.19 U26.30 U26.41 U26.48 U47.2 U48.24 X2.1 | length 107.9
  Top Layer w0.15: R222.1@46.1,44.4 46.714,45.014 46.714,45.139 v1(46.8,45.225)
  Top Layer w0.156: C135.2@52.325,21.325 52.35,21.35 R221.2@53.25,21.35 54.05,21.35 v1(54.5,21.8) ; v1(52.871,25.547) v1@52.934,25.484
  Top Layer w0.2: U16.24@43,40.8 43,40.1 C111.2@43.6,39.5
  Top Layer w0.25: v1(0.8,58.5) 0.8,57.5 0.9,57.4 ; U7.8@1.5,55.9 0.9,55.9 ; U7.7@1.5,56.4 0.9,56.4 ; U7.6@1.5,56.9 0.9,56.9 ; U7.5@1.5,57.4 0.9,57.4 ; R7.2@1.8,54.7 v1(1.1,54.7) 1.033,54.767 1.033,55.313 0.9,55.446 0.9,55.9 ; v1(5.8,58) R56.2@6.5,58 ; C160.2@43.75,19.8 43.75,20.25 44.015,20.515 44.537,20.515 v1@44.59,20.567 ; C162.2@44.575,19.803 44.59,19.818 v1@44.59,20.567 ; C164.2@45.424,19.803 45.299,19.928 45.299,20.363 45.148,20.515 44.671,20.515 v1(44.604,20.582) v1@44.59,20.567 ; C144.2@51.4,21.325 51.402,21.323 51.402,20.584 v1(51.404,20.582) 51.452,20.629 52.079,20.629 52.325,20.875 C135.2@52.325,21.325 ; v1(51.55,43.875) v1@51.617,43.808 ; v1(52.871,25.547) v1@52.872,25.548 ; C153.2@52.874,26.318 C153.2@52.874,26.318 v1@52.872,25.548 ; C137.2@53.674,26.318 53.674,25.868 53.42,25.614 52.938,25.614 v1@52.872,25.548 ; v1@83.445,73.1 R133.1@84.2,73.1 ; v1(87.675,91.678) L32.2@87.675,92.643 ; L25.1@94.21,23.9 v1(94.21,24.838) ; 0.9,55.9 0.9,56.4 ; 0.9,56.4 0.9,56.9 ; 0.9,56.9 0.9,57.4
  Top Layer w0.3: v1(45.05,35.6) 45.131,35.6 45.281,35.75 47.55,35.75 48.3,35.75 RA1.4@48.35,35.8 ; v1(60.55,98.75) C14.2@61.25,98.75 U5.8@62.4,98.75 ; U5.3@65.2,99.75 U5.2@65.2,99.25 U5.1@65.2,98.75 v1(66.1,98.75)
  Top Layer w0.4: C111.2@43.6,39.5 43.6,39 43.9,38.7 v1(44.5,38.7) ; C150.2@46.364,26.75 46.464,26.65 v1(47.3,26.65) ; v1@47.325,26.625 47.825,26.625 C140.2@48.1,26.9 ; v1(58.65,98.75) L29.1@58.65,99.61
  Top Layer w0.5: v1(0.8,58.5) C16.2@1.5,58.5 ; C161.2@19.35,29.8 v1(19.35,30.5) ; C157.2@20.2,29.8 v1(20.2,30.5) ; C147.2@44.6,24.3 v1(45.4,24.3) ; v1(47.3,26.65) v1@47.325,26.625
  L3-Signal w0.15: 56.535,54.785 56.55,54.8
  L3-Signal w0.6: J2.6@56.535,53.775 56.535,54.785
  Bottom Layer w0.15: R58.2@50.7,49.35 50.05,48.7 50.05,46.95 51.65,45.35 51.65,44.698 51.55,44.598 v1(51.55,43.875) ; v1(59.8,63.65) 59.85,63.6 R274.2@60.6,63.6 ; v1(66.375,52) 67.5,52 70.6,55.1 70.6,59.45 71.4,60.25 R275.2@71.45,60.25 73.3,62.1 75.55,62.1 76.1,61.55 76.1,60.85 76.9,60.05 78.65,60.05 79.2,60.6 R276.2@79.2,62.669
  Bottom Layer w0.156: R220.2@42.8,31.675 v1(43.775,31.675) ; v1(51.404,20.582) 51.404,20.502 51.7,20.206 R267.1@51.7,19.672
  Bottom Layer w0.2: v1(28.2,77) 28.85,77 R264.1@29.2,76.65 ; Q15.5@31.025,75.55 Q15.2@32.375,75.55 33.322,75.55 33.422,75.65 34.15,75.65 34.2,75.6 R269.1@34.5,75.6 v1(35.45,75.6) ; R224.2@36.4,73.2 36.4,73.648 36.752,74 v1(36.85,74) ; v1(40.25,68.85) R85.2@40.25,69.65 ; R215.1@42.35,41 42.35,40.45 44.076,38.724 44.476,38.724 v1(44.5,38.7) ; U26.19@44.6,24.325 44.612,24.312 45.388,24.312 v1(45.4,24.3) ; v1(47.3,26.65) 47.75,27.1 U26.30@47.75,27.475 ; v1(62.1,61.35) 62.186,61.436 62.186,61.661 62.325,61.8 C215.2@62.8,61.8 62.8,61.775 62.95,61.625 63.2,61.625 63.6,61.225 63.6,60.95 63.7,60.85 U48.24@63.975,60.85
  Bottom Layer w0.25: v1(5.85,26.45) R61.2@5.85,27.25 ; R157.2@18.466,33.4 18.466,31.984 19.35,31.1 v1(19.35,30.5) ; R147.2@44.2,69.6 v1(44.95,69.6) ; R140.2@44.2,76.7 v1(44.9,76.7) ; v1@44.6,20.586 U26.13@44.6,21.325 ; v1@51.4,20.586 U26.48@51.4,21.325 ; U26.41@51.4,24.825 51.762,24.825 51.837,24.9 52.672,24.9 52.7,24.872 52.807,24.872 R121.2@52.875,24.803 v1@52.875,25.543 ; R265.1@54.5,21.05 v1(54.5,21.8) ; R120.2@64.35,51.25 R115.2@65.35,51.25 R117.1@66.35,51.25 66.362,51.262 66.362,51.988 v1(66.375,52) ; R4.1@65.1,53.05 66.29,53.05 L3.1@66.3,53.06 L3.1@66.35,53.01 ; v1(67.9,67.9) 68.54,68.54 68.825,68.54 69.16,68.875 L4.2@69.16,68.9 ; U47.2@88.975,48.025 U47.2@89,48.05 89,47.1 89.221,46.879 89.221,46.479 C216.2@89.3,46.4 R183.2@89.3,45.5 R184.2@89.3,44.62 v1@89.3,43.908
  Bottom Layer w0.3: L3.1@66.35,53.01 L3.1@66.375,52.985
  Bottom Layer w0.5: v1(66.375,52) L3.1@66.375,52.985
  other v1: 89.301,43.907 83.437,73.107
1V8_CAN: C119.1 C120.1 L25.2 R90.1 R91.2 R225.1 R226.1 R227.1 R228.1 U20.1 U21.1 | length 40.9
  Top Layer w0.15: R227.1@89.1,25.05 R225.1@90,25.05 R226.1@90.9,25.05 R228.1@91.8,25.05
  Top Layer w0.25: R228.1@91.8,25.05 v1(91.8,25.787) ; U20.1@106.819,9.065 106.819,10.271 106.78,10.31 106.829,10.359 106.829,10.789 v1(107.6,11.56)
  Top Layer w0.5: U21.1@95.72,21.505 95.788,21.573 C120.1@95.788,22.784 95.788,23.9 95.8,23.912 v1(95.8,24.85)
  L3-Signal w0.5: v1(91.8,25.787) 94.863,25.787 v1(95.8,24.85) 95.8,17.8 97.3,16.3 97.3,13.85 99.1,12.05 103.618,12.05 103.62,12.052 104.703,12.052 105.966,10.789 107.005,10.789 107.581,11.364 107.581,11.541 v1(107.6,11.56)
  Bottom Layer w0.5: v1(95.8,24.85) 95.827,24.85 96.127,24.55 97.25,24.55 97.5,24.3 R90.1@97.5,24 ; v1@107.61,11.55 R91.2@108.6,11.55
1V8_SW: C242.2 C247.2 C249.2 J15.23 J15.24 R200.2 R201.2 R203.2 R207.2 R208.2 R210.2 U65.6 X80.1 | length 15.8
  Top Layer w0.25: J15.23@6.881,86.478 v1(8.05,86.478) ; C249.2@8.85,86.928 8.734,86.813 8.384,86.813 v1(8.05,86.478) ; R210.2@11.3,87.628 11.3,85.919 10.934,85.553 9.148,85.553 9.001,85.699 9.001,86.003 8.876,86.128 C247.2@8.85,86.128 8.748,86.23 8.371,86.23 8.123,86.478 v1(8.05,86.478)
  Top Layer w0.4: v1(2.913,86.978) J15.24@4.081,86.978
  Bottom Layer w0.15: 14.175,84.742 R200.2@14.892,84.742 ; 14.175,85.767 R201.2@14.892,85.767 ; 14.175,86.792 R207.2@14.892,86.792 ; 14.175,87.842 R208.2@14.892,87.842 ; C242.2@22.9,98.35 23.3,97.95 23.3,97.925 23.625,97.6 R203.2@23.625,96.95
  Bottom Layer w0.5: U65.6@20.725,98.185 20.752,98.212 21.912,98.212 22.15,98.45 C242.2@22.875,98.45
1V8C: C9.2 C10.2 C11.2 C12.2 C13.2 C15.2 L4.1 R9.2 R10.2 R11.2 U3.1 U3.8 U3.14 U3.22 U6.3 U6.7 U6.8 | length 28.6
  Bottom Layer w0.25: R11.2@55.817,69.911 55.817,71.127 56.171,71.481 U6.3@57.556,71.481 60.131,71.481 61.401,70.211 ; U6.7@63.017,70.211 61.401,70.211 ; v1(63.786,67.546) C15.2@62.986,67.546 62.986,68.911 U6.8@63.017,68.941 61.548,68.941 61.401,69.088 61.401,70.211 ; 71.35,72.4 71,72.05 C9.2@71,71.5 ; U3.1@72.35,67.95 70.85,67.95 C11.2@70.75,67.85 70.75,70.3 71,70.55 C9.2@71,71.5 ; U3.8@72.35,71.45 71.05,71.45 C9.2@71,71.5 ; 74.775,73.35 C13.2@75.5,73.35 U3.14@75.5,72.1 ; U3.22@77.15,68.95 77.637,68.95 77.787,68.8 C10.2@78.6,68.8 78.6,68.765 78.725,68.64 79.956,68.64 ; R10.2@79.838,71 R9.2@79.838,70 80.563,70
2V5: C143.2 C146.2 C149.2 C152.2 C155.2 C165.2 R22.2 R127.2 U26.3 U26.9 U29.6 X52.1 | length 15.4
  Top Layer w0.5: C146.2@45.95,21.4 v1(46.75,21.4) 46.725,21.425 46.725,21.925 46.4,22.25 C143.2@45.95,22.25 ; C155.2@48.95,21.4 v1(49.75,21.4) ; C152.2@49.8,20.6 49.775,20.625 49.775,21.375 v1(49.75,21.4) ; C149.2@50.5,21.5 50.45,21.45 49.8,21.45 v1(49.75,21.4)
  Top Layer w0.6: R22.2@40.55,29.45 v1(42,29.45)
  L4-Signal w0.6: v1(46.75,21.4) v1(49.75,21.4)
  Bottom Layer w0.2: U26.9@46.75,20.675 v1(46.75,21.4) ; U26.3@49.75,20.675 v1(49.75,21.4)
  Bottom Layer w0.5: U29.6@58.4,21.9 58.4,19.36 58.465,19.295 R127.2@58.465,18.45 58.45,18.435 X52.1@58.45,17.1
  other v1: 58.465,19.268
3V2_AIN1: C183.1 C191.2 C194.1 C195.2 C197.2 C199.2 C203.2 R165.1 R168.2 R170.2 R172.2 U37.6 U39.3 U39.9 U39.12 U39.13 U41.5 U43.16 X61.1 | length 20.4
  Bottom Layer w0.15: C197.2@104.95,64.2 C197.2@104.975,64.175 ; U39.9@104.975,62.25 104.962,62.262 104.962,63.488 v1(104.95,63.5) 104.95,63.95 C197.2@104.975,63.975 ; U39.12@106.925,62.25 106.925,64.175 C195.2@106.95,64.2 ; U39.13@107.575,62.25 107.65,62.325 107.65,63.278 107.75,63.378 C199.2@107.75,64.2 ; R172.2@108.65,65.2 R170.2@109.55,65.2 R168.2@110.45,65.2
  Bottom Layer w0.25: U39.3@108.225,55.75 v1(108.225,57.35) ; R172.2@108.65,65.2 v1(108.65,65.928) ; C183.1@115.325,53.85 U37.6@115.325,55.073 v1(115.325,56.023)
  Bottom Layer w0.5: U43.16@102.95,53.018 103.6,53.018 103.731,53.149 104.381,53.149 v1(104.4,53.168) ; v1@104.402,53.166 C203.2@105.242,53.166 ; R165.1@109.747,70.852 U41.5@108.13,70.852 108.13,70.048 108.335,69.843 108.385,69.843 108.66,69.568 C194.1@108.66,69.543 108.66,69.518 110.235,69.518 110.282,69.565 v1(111.46,69.565)
  other v1: 106.946,63.482 107.75,63.5
3V2_AIN2: C184.1 C192.2 C193.1 C196.2 C198.2 C201.2 C204.2 R164.1 R169.2 R171.2 R173.2 U38.6 U40.1 U40.3 U40.9 U40.12 U40.13 U42.5 U45.16 X60.1 | length 21.9
  Bottom Layer w0.25: v1(108.65,89.278) R173.2@108.65,88.55 R171.2@109.55,88.55 R169.2@110.45,88.55 ; U38.6@114.825,78.126 C184.1@114.825,76.921 114.836,76.911 115.589,76.911 v1(115.6,76.9)
  Bottom Layer w0.3: C196.2@104.95,87.55 v1(104.95,86.8) 104.962,86.788 104.962,85.612 U40.9@104.975,85.6 ; U40.12@106.925,85.6 106.925,87.525 C198.2@106.95,87.55 ; U40.13@107.575,85.6 107.65,85.675 107.65,86.628 107.75,86.728 C201.2@107.75,87.55 ; U40.3@108.225,79.1 v1(108.225,80.7) ; U40.1@109.525,79.1 v1(109.525,80.7)
  Bottom Layer w0.5: U45.16@102.969,76.309 v1@104.349,76.309 ; v1(104.35,76.31) 104.355,76.305 105.195,76.305 C204.2@105.2,76.3 ; R164.1@109.7,94.25 109.694,94.243 108.076,94.243 U42.5@108.07,94.237 108.07,93.433 108.275,93.228 108.325,93.228 108.6,92.953 C193.1@108.6,92.903 110.175,92.903 C192.2@110.2,92.928 110.222,92.95 v1(111.4,92.95)
  other v1: 106.946,86.832 107.75,86.85