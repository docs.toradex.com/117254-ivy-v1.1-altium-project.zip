# Altium PCB 46806005.~(2).PcbDoc (part 6 of 9)
Units mm, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 130 x 105 mm, 8 copper layers (Top Layer, P1-GND, L1-Signal, L2-Signal, L3-Signal, L4-Signal, P2-GND, Bottom Layer), stack 1.63 mm thick; 797 components, 496 nets, 2816 pads, 1210 vias.
Unrouted connection lines stored in the file: 1.

## Via types
v1: diameter 0.6, hole 0.3, Top Layer to Bottom Layer, tented both sides, 1145 vias
v2: diameter 0.6, hole 0.3, Top Layer to Bottom Layer, 65 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
GND_CAN2: C122.2 C123.1 C126.1 C128.1 C130.2 C131.1 J6.5 J6.7 R240.2 U19.9 U19.10 U19.11 U19.12 U19.15 U19.16 U21.5 U23.2 U23.8 U25.3 X33.1 | length 26.6
  Top Layer w0.25: U23.2@103.8,18.93 105.38,18.93 v1(105.4,18.95)
  Top Layer w0.5: U21.5@101.181,17.695 101.181,17.623 101.301,17.503 101.301,16.749 v1(101.7,16.35) ; v1(102.3,22.5) C130.2@103,22.5 ; v1(102.469,24.044) 103.401,24.044 104.2,23.245 104.2,22.512 C123.1@104.212,22.5 ; v1(107.9,20.2) U23.8@109.261,20.2 ; v1(108.25,14.45) C128.1@108.25,15.15
  Bottom Layer w0.25: v1(115.075,24.25) U25.3@115.9,24.25
  Bottom Layer w0.5: R240.2@100.7,15.2 100.745,15.155 U19.16@103.85,15.155 v1(105.231,15.156) ; v1@102.47,24.045 U19.9@103.85,24.045 ; U19.15@103.81,16.4 103.822,16.412 105.19,16.412 v1(105.202,16.4) ; U19.12@103.815,20.25 103.822,20.242 105.195,20.242 v1(105.202,20.25) ; U19.11@103.85,21.505 102.615,21.505 102.3,21.82 v1(102.3,22.5) 102.333,22.5 102.608,22.775 U19.10@103.85,22.775 ; v1(106.05,15.875) C122.2@106.05,16.7 ; X33.1@106.7,23.8 C131.1@108.7,23.8 ; C126.1@107.6,15.625 107.7,15.625 108.225,15.1 108.225,15 108.25,14.975 v1(108.25,14.45)
GPIO1: M1.206 R9.1 U3.20 X6.1 | length 30.3
  Top Layer w0.25: M1.206@65.5,65.6 65.5,67.4 v1(66,67.9)
  L1-Signal w0.15: v1(66,67.9) 67.25,69.15 68.85,69.15 71.6,71.9 76.05,71.9 77.35,70.6 77.35,70.238 77.663,69.925 78.625,69.925 v1(79.3,69.25)
  L2-Signal w0.15: v1(79.3,69.25) 81.55,71.5 81.55,72.7 83.75,74.9 X6.1@85.15,74.9
  Bottom Layer w0.25: U3.20@77.15,69.95 77.2,70 77.662,70 77.694,69.968 78.806,69.968 R9.1@78.838,70 79.3,69.538 v1(79.3,69.25)
GPIOs.GPIO2: J2.8 M1.208 | length 18.3
  Top Layer w0.15: v1(59.4,62.7) 60.858,62.7 61.233,62.325 63.299,62.325 63.674,62.7 63.883,62.7 64.827,63.644 65.044,63.644 65.988,64.588 65.988,65.588 M1.208@66,65.6
  L1-Signal w0.15: J2.8@57.805,53.775 58.8,54.77 58.8,57.8 59.425,58.425 59.425,59.125 59.425,62.675 v1(59.4,62.7)
GPIOs.GPIO3: J2.10 M1.210 | length 17.5
  Top Layer w0.15: v1(60,62.15) 60.983,62.15 61.183,61.95 63.558,61.95 64.858,63.25 65.2,63.25 66.5,64.55 M1.210@66.5,65.6
  L1-Signal w0.15: J2.10@59.075,53.775 59.075,54.099 59.075,54.621 59.1,54.645 59.1,57.676 59.6,58.176 59.725,58.301 59.725,59.249 59.725,61.875 v1(60,62.15)
GPIOs.GPIO4: M1.212 R11.1 U6.1 X11.1 | length 15.8
  Top Layer w0.15: v1(59.05,68.95) 59.063,68.95 59.563,69.45 65.2,69.45 67,67.65 M1.212@67,65.6
  Bottom Layer w0.15: X11.1@54.35,68.651 54.611,68.911 R11.1@55.817,68.911 55.847,68.941 U6.1@57.556,68.941 57.561,68.946 59.046,68.946 v1(59.05,68.95)
I2C1_SCL: J2.13 M1.14 R140.1 R229.2 U5.6 U7.2 X10.1 | length 155.8
  Top Layer w0.15: U7.2@3.4,56.4 3.85,56.4 4.05,56.6 4.05,57.95 2.4,59.6 2.4,63.45 7.55,68.6 14.45,68.6 v1@15,68.05 ; v1(14.9,67.95) v1@15,68.05 ; M1.14@15.5,65.6 15.5,67.55 v1@15,68.05 ; X10.1@60.7,102.5 60.7,101.475 61.725,100.45 61.725,100.025 62,99.75 U5.6@62.4,99.75
  L2-Signal w0.15: v1(38.15,75.4) 40.6,72.95 40.6,71.474 41.724,70.35 42.426,70.35 43.15,71.074 43.15,77.676 45.75,80.276 45.75,83.524 53.95,91.724 53.95,98.75 55.251,100.051 55.251,100.794 55.631,101.173 56.373,101.173 57.8,102.6 60.6,102.6 X10.1@60.7,102.5
  L3-Signal w0.15: v1(38.15,75.4) 39.2,74.35 39.2,71.776 44.751,66.225 53.049,66.225 64.4,54.874 64.4,52.716 63.413,51.73 62.39,51.73 J2.13@61.615,52.505
  Bottom Layer w0.15: v1(14.9,67.95) 15.35,67.5 15.35,67.038 15.788,66.6 22.226,66.6 28.476,72.85 34.95,72.85 36.75,74.65 37.85,74.65 38.15,74.95 v1(38.15,75.4) 38.15,75.85 38.45,76.15 41.9,76.15 42.45,76.7 R140.1@43.2,76.7
  Bottom Layer w0.25: v1(38.15,75.4) R229.2@39.25,75.4
I2C1_SCL_MPCIe: R136.1 R142.1 U31.6 | length 37.3
  Top Layer w0.15: R136.1@50.9,101.85 50.925,101.875 U31.6@52.58,101.875 53.775,101.875 v1(53.8,101.9)
  L2-Signal w0.15: v1(42.15,73.9) 41.55,74.5 41.55,76.15 41.8,76.4 41.8,77.623 44.85,80.673 44.85,83.897 52.9,91.947 52.9,101 v1(53.8,101.9)
  Bottom Layer w0.25: v1(42.15,73.9) R142.1@43.25,73.9
I2C1_SDA: J2.15 M1.12 R147.1 R230.2 U5.5 U7.1 X9.1 | length 157.8
  Top Layer w0.15: U7.1@3.4,55.9 3.9,55.9 4.35,56.35 4.35,58.1 2.7,59.75 2.7,63.326 7.374,68 13.798,68 v1(14.58,67.218) 15,66.798 M1.12@15,65.6 ; U5.5@62.4,100.25 62.4,101.4 X9.1@63.5,102.5
  L2-Signal w0.15: v1(38.15,72.4) 37.45,73.1 37.45,74.05 37.9,74.5 38.6,74.5 40.15,72.95 40.15,71.5 41.6,70.05 42.55,70.05 43.45,70.95 43.45,77.551 48.549,82.65 49,82.65 49.35,83 49.35,86.7 54.3,91.65 54.3,98.676 55.551,99.927 55.551,100.669 55.755,100.873 61.873,100.873 X9.1@63.288,102.288
  L3-Signal w0.15: v1(38.15,72.4) 44.625,65.925 52.925,65.925 64.1,54.75 64.1,52.841 63.764,52.505 J2.15@62.885,52.505
  Bottom Layer w0.15: v1(14.58,67.218) 15.498,66.3 22.35,66.3 28.45,72.4 v1(38.15,72.4) 38.15,72 36.35,70.2 36.35,69.3 37.4,68.25 41.85,68.25 R147.1@43.2,69.6
  Bottom Layer w0.25: v1(38.15,72.4) R230.2@39.25,72.4
I2C1_SDA_MPCIe: R137.1 R143.1 U31.5 | length 38.4
  Top Layer w0.15: U31.5@52.58,102.525 52.58,103.93 R137.1@52.6,103.95
  L2-Signal w0.15: v1(42.15,72.4) 41.25,73.3 41.25,75.95 41.25,76.274 41.5,76.524 41.5,77.747 44.55,80.797 44.55,84.021 52.6,92.071 v1(52.6,103.2)
  Bottom Layer w0.25: v1(42.15,72.4) R143.1@43.25,72.4
I2C4_SCL: J2.14 M1.95 R183.1 U47.3 X64.1 | length 67.9
  Top Layer w0.15: M1.95@35.75,57.4 35.75,56.088 35.838,56 40.774,56 42.25,54.524 42.25,53.7 X64.1@43.25,52.7
  L2-Signal w0.15: X64.1@43.25,52.7 44.15,53.6 46.508,53.6 46.558,53.65 46.583,53.625 47.017,53.625 47.042,53.65 47.092,53.6 50.1,53.6 53.8,57.3 58.09,57.3 59.765,55.625 60.117,55.625 60.425,55.317 60.425,54.965 J2.14@61.615,53.775 62.39,54.55 66.467,54.55 75.517,45.5 v1(87.55,45.5)
  Bottom Layer w0.15: R183.1@88.3,45.5 v1(87.55,45.5) 87.05,45.5 86.65,45.9 86.65,46.75 86.95,47.05 87.899,47.05 88.225,47.376 88.225,47.925 U47.3@88.35,48.05
I2C4_SCL_3V3: R181.1 R251.1 R257.1 U43.6 U45.6 U47.6 | length 49.3
  Top Layer w0.15: v1(94.831,59.369) 96.294,59.369 R251.1@96.6,59.063
  Top Layer w0.25: v1(94.831,82.659) 94.846,82.659 95.152,82.353 R257.1@96.6,82.353
  L2-Signal w0.15: v1(94.831,59.369) 95.8,60.338 95.8,81.69 v1(94.831,82.659)
  Bottom Layer w0.15: R181.1@85.5,50.745 86.755,50.745 87.125,50.375 88.175,50.375 88.35,50.55 U47.6@88.35,51.59 88.35,52.75 88.15,52.95 88.15,53.6 89.55,55 95.1,55 95.65,55.55 95.65,58.55 v1(94.831,59.369)
  Bottom Layer w0.25: U43.6@93.45,59.368 v1@94.83,59.368 ; U45.6@93.45,82.658 v1(94.831,82.659)
I2C4_SDA: J2.16 M1.93 R184.1 U47.4 X65.1 | length 71.6
  Top Layer w0.15: M1.93@35.25,57.4 35.25,56.1 35.65,55.7 40.65,55.7 41.95,54.4 41.95,51.4 X65.1@43.25,50.1
  L2-Signal w0.15: X65.1@43.25,50.1 43.275,50.075 50.283,50.075 50.333,50.025 50.767,50.025 50.817,50.075 52.55,50.075 52.74,49.885 61.785,49.885 63.75,51.85 63.75,52.91 J2.16@62.885,53.775 66.818,53.775 75.972,44.62 v1(87.568,44.62)
  Bottom Layer w0.15: U47.4@87.7,48.05 87.663,48.013 87.363,48.013 86.25,46.9 86.25,45.35 86.98,44.62 v1(87.568,44.62) R184.1@88.3,44.62
I2C4_SDA_3V3: R180.1 R252.1 R258.1 U43.3 U45.3 U47.5 | length 42.7
  Top Layer w0.15: v1(94.831,55.559) 95.704,55.559 95.935,55.328 96.225,55.328 96.6,54.953 R252.1@96.6,54.663
  Top Layer w0.25: v1(94.831,78.849) 95.704,78.849 95.935,78.618 96.225,78.618 96.6,78.243 R258.1@96.6,77.953
  L2-Signal w0.15: v1(94.831,55.559) 94.14,56.25 94.14,62.39 95.5,63.75 95.5,78.18 v1(94.831,78.849)
  Bottom Layer w0.15: R180.1@85.5,51.745 86.305,51.745 86.46,51.59 U47.5@87.7,51.59 87.7,53.65 89.608,55.558 U43.3@93.45,55.558
  Bottom Layer w0.25: U43.3@93.45,55.558 v1@94.83,55.558 ; U45.3@93.45,78.848 v1(94.831,78.849)
I2C_3.I2C3_SCL: M1.59 R224.1 R232.2 | length 28
  Top Layer w0.15: M1.59@26.75,57.4 26.75,58.578 26.9,58.728 v1(26.9,59.3)
  L2-Signal w0.15: v1(26.9,59.3) 26.9,61.75 27.95,62.8 27.95,66.142 29.708,67.9 36.15,67.9 38.75,70.5 38.75,73.3 v1(38.15,73.9)
  Bottom Layer w0.25: R224.1@37.4,73.2 37.4,73.8 37.5,73.9 v1(38.15,73.9) R232.2@39.25,73.9
I2C_3.I2C3_SDA: M1.57 R85.1 R231.2 | length 24.2
  Top Layer w0.15: M1.57@26.25,57.4 v1(26.25,59.8)
  L2-Signal w0.15: v1(26.25,59.8) 26.25,61.708 27.65,63.108 27.65,66.267 29.583,68.2 35.55,68.2 v1(37.15,69.8)
  Bottom Layer w0.25: v1(37.15,69.8) 38.25,70.9 R231.2@39.25,70.9 R85.1@39.25,69.65
I2C_PCIE_SCL: R145.1 R229.1 R232.1 U31.3 | length 39.5
  Top Layer w0.15: v1(54.966,103.275) 54.947,103.256 54.947,102.003 55.075,101.875 U31.3@56.12,101.875
  L2-Signal w0.15: v1(42.1,75.4) 42.1,77.499 45.15,80.549 45.15,83.773 53.35,91.973 53.35,99.35 54.651,100.651 54.651,101.042 54.966,101.357 v1(54.966,103.275)
  Bottom Layer w0.15: R232.1@40.95,73.9 R229.1@40.95,75.4 v1(42.1,75.4) R145.1@43.25,75.4
I2C_PCIE_SDA: R144.1 R230.1 R231.1 U31.4 | length 42.8
  Top Layer w0.15: v1(56.102,103.275) 56.12,103.257 U31.4@56.12,102.525
  L2-Signal w0.15: v1(42.1,70.9) 42.823,71.623 42.823,77.773 45.45,80.4 45.45,83.649 53.65,91.849 53.65,99.226 54.951,100.527 54.951,100.918 55.4,101.367 55.4,102.573 v1(56.102,103.275)
  Bottom Layer w0.15: R230.1@40.95,72.4 R231.1@40.95,70.9 v1(42.1,70.9) R144.1@43.25,70.9 R144.1@43.2,70.85
I2S_2_BCLK: M1.42 R209.1 | length 30.6
  Top Layer w0.15: R209.1@15.3,87.65 15.35,87.65 16.15,88.45 19.9,88.45 24.6,83.75 24.6,69.05 22.5,66.95 M1.42@22.5,65.6
JTAG1_TCK: J13.4 M1.9 U66.1 | length 34.6
  Top Layer w0.15: v1(13.15,59.9) 14.05,59 14.05,58.608 14.245,58.412 14.245,57.405 M1.9@14.25,57.4 ; v1(18.637,40.79) U66.1@18.637,39.675 18.637,39.36 17.01,37.733 17.01,34.49 17.82,33.68 J13.4@19.4,33.68
  L1-Signal w0.15: v1(13.15,59.9) 13.15,58.924 12.525,58.299 12.525,49.574 18.075,44.024 18.075,43.083 18.637,42.52 v1(18.637,40.79)
JTAG1_TDI: J13.8 M1.1@12.25,57.4 U67.1 | length 35.4
  Top Layer w0.15: v1(11.4,58.9) 11.446,58.854 11.796,58.854 12.238,58.412 12.238,57.412 M1.1@12.25,57.4 ; J13.8@19.4,36.22 20.82,36.22 21.7,37.1 21.7,38.15 22.25,38.7 U67.1@22.25,39.725 v1(22.25,40.84)
  L1-Signal w0.15: v1(11.4,58.9) 11.4,58.787 11.6,58.587 11.6,49.2 17.15,43.65 17.15,40.55 18.05,39.65 20.667,39.65 21.857,40.84 v1(22.25,40.84)
JTAG1_TDO: J13.6 M1.5 U66.3 | length 38.4
  Top Layer w0.15: v1@12.1,60.249 12.1,59.674 13.25,58.524 M1.5@13.25,57.4 ; J13.6@19.4,34.95 17.8,34.95 17.35,35.4 17.35,37.35 18.15,38.15 20.2,38.15 20.537,38.487 U66.3@20.537,39.675 20.6,39.738 v1(20.6,40.75)
  L1-Signal w0.15: v1(12.099,60.25) 12.099,59.375 12.225,59.249 12.225,49.449 17.775,43.899 17.775,40.91 18.42,40.265 19.015,40.265 19.5,40.75 v1(20.6,40.75)
JTAG1_TMS: J13.2 M1.13 U66.6 | length 37.3
  Top Layer w0.15: v1(13.95,60.15) 13.992,60.15 15.275,58.867 15.275,58.433 15.255,58.412 15.255,57.405 M1.13@15.25,57.4 ; v1(18.6,43.4) 18.6,42.222 U66.6@18.637,42.185 17.785,42.185 17.2,41.6 17.2,40.15 16.6,39.55 16.6,33.7 17.89,32.41 J13.2@19.4,32.41
  L1-Signal w0.15: v1(13.95,60.15) 13.95,59.3 12.825,58.175 12.825,49.698 18.578,43.945 18.578,43.422 v1(18.6,43.4)
JTAG1_TRST#: J13.10 M1.3 U67.6 | length 39.9
  Top Layer w0.15: v1(11.35,59.7) 11.436,59.614 11.636,59.614 12.75,58.5 M1.3@12.75,57.4 ; J13.10@19.4,37.49 20.94,37.49 21.35,37.9 21.35,41.02 22.25,41.92 U67.6@22.25,42.235 v1(22.25,43.35)
  L1-Signal w0.15: v1(11.35,59.7) 11.925,59.125 11.925,49.325 17.45,43.8 17.45,40.81 18.295,39.965 20.558,39.965 21.4,40.807 21.4,42.5 v1(22.25,43.35)
JTAG.JTAG1_VREF: J13.1 M1.7 U67.3 | length 42.4
  Top Layer w0.15: M1.7@13.75,57.4 13.75,58.5 12.6,59.65 12.6,60.092 13.208,60.7 14.2,60.7 v1(14.75,60.15) ; J13.1@23.3,32.41 24.12,32.41 24.689,32.979 24.737,32.979 25.025,33.267 25.025,37.875 24.15,38.75 U67.3@24.15,39.725 v1(24.15,40.84)
  L1-Signal w0.15: v1(14.75,60.15) 14.75,59.6 13.125,57.975 13.125,49.822 19.047,43.9 22.442,43.9 24.15,42.192 v1(24.15,40.84)
LEDs.GPIO1: M1.30 Q1.2 R67.2 | length 57.7
  Top Layer w0.15: v1(16.025,67.35) 16.05,67.35 16.35,67.65 18.65,67.65 19.5,66.8 M1.30@19.5,65.6
  L1-Signal w0.15: v1(1.95,24.4) 1.971,24.421 1.971,24.821 4.05,26.9 4.05,58.265 5.435,59.65 6.327,59.65 8.084,61.407 8.084,62.034 11.828,65.778 14.453,65.778 v1(16.025,67.35)
  Bottom Layer w0.15: v1(1.95,24.4) R67.2@2.75,24.4 Q1.2@2.75,23.475
LEDs.GPIO2: M1.32 Q1.5 R70.2 | length 63.1
  Top Layer w0.15: v1(15.95,68.1) 18.8,68.1 20,66.9 M1.32@20,65.6
  L1-Signal w0.15: v1(2.45,21.45) 4.9,23.9 4.9,29.85 4.35,30.4 4.35,58.141 5.559,59.35 6.451,59.35 8.384,61.282 8.384,61.828 12.034,65.478 14.93,65.478 16.55,67.099 16.55,67.567 16.017,68.1 v1(15.95,68.1)
  Bottom Layer w0.15: R70.2@2.25,20.5 2.25,21.128 2.45,21.328 v1(2.45,21.45) 2.456,21.45 2.75,21.744 Q1.5@2.75,22.125
LEDs.GPIO3: M1.34 Q2.2 R71.2 | length 62.4
  Top Layer w0.15: v1(15.5,69.3) 16.35,68.45 19.25,68.45 20.5,67.2 M1.34@20.5,65.6
  L1-Signal w0.15: v1(5.75,24.4) 5.2,24.95 5.2,29.995 4.65,30.545 4.65,58.017 5.683,59.05 6.576,59.05 8.684,61.158 8.684,61.704 12.158,65.178 15.054,65.178 16.85,66.974 16.85,67.95 v1(15.5,69.3)
  Bottom Layer w0.15: Q2.2@4.95,23.475 R71.2@4.95,24.4 v1(5.75,24.4)
LEDs.GPIO4: M1.36 Q2.5 R74.2 | length 64.5
  Top Layer w0.15: v1(16.85,69.05) 19.35,69.05 21,67.4 M1.36@21,65.6
  L1-Signal w0.15: v1(4.95,21.45) 4.95,22.6 6.4,24.05 6.4,29.628 4.95,31.078 4.95,57.892 5.808,58.75 6.7,58.75 8.984,61.034 8.984,61.579 12.283,64.878 15.178,64.878 17.15,66.85 17.15,68.074 16.85,68.374 v1(16.85,69.05)
  Bottom Layer w0.15: R74.2@4.95,20.5 v1(4.95,21.45) Q2.5@4.95,22.125
LEDs.GPIO5: M1.54 Q3.2 R75.2 | length 53
  Top Layer w0.15: M1.54@25.5,65.6 25.5,64.55 25.725,64.325 27.017,64.325 27.325,64.017 27.325,62.783 26.733,62.191 26.429,62.191 26.412,62.208 25.986,62.208 v1(25.9,62.294)
  L1-Signal w0.15: v1(12.614,25.215) 13.399,26 14.35,26 16.85,28.5 16.85,30.475 17.4,31.025 17.4,33.447 21.703,37.75 23.015,37.75 24.75,39.485 24.75,53.3 23.15,54.9 23.15,56.15 25.4,58.4 25.4,61.794 v1(25.9,62.294)
  Bottom Layer w0.15: Q3.2@12.614,23.49 R75.2@12.614,24.415 v1(12.614,25.215)
LEDs.GPIO6: M1.44 Q3.5 R78.2 | length 59.6
  Top Layer w0.15: M1.44@23,65.6 23,63.8 23.75,63.05 v1(25.85,63.05)
  L1-Signal w0.15: v1(12.614,21.365) 14.215,21.365 15.75,22.9 15.75,26.551 17.45,28.251 17.45,30.226 18,30.776 18,33.199 21.951,37.15 23.263,37.15 25.35,39.237 25.35,53.549 23.75,55.149 23.75,55.867 24.839,56.956 25.982,56.956 27.425,58.399 27.425,62.617 26.767,63.275 26.197,63.275 25.972,63.05 v1(25.85,63.05)
  Bottom Layer w0.15: R78.2@12.614,20.515 v1(12.614,21.365) Q3.5@12.614,22.14
LEDs.GPIO7: M1.46 Q4.2 R79.2 | length 51.5
  Top Layer w0.15: M1.46@23.5,65.6 23.5,64.209 24.241,63.468 25.247,63.468 25.354,63.575 26.217,63.575 26.517,63.275 26.517,62.783 v1(26.55,62.75)
  L1-Signal w0.15: v1(15.203,25.204) 15.214,25.215 15.214,26.44 17.15,28.376 17.15,30.351 17.7,30.901 17.7,33.323 21.827,37.45 23.139,37.45 25.05,39.361 25.05,53.424 23.45,55.024 23.45,55.991 25.7,58.241 25.7,61.137 26.55,61.987 v1(26.55,62.75)
  Bottom Layer w0.15: v1(15.203,25.204) 15.214,25.204 R79.2@15.214,24.415 Q4.2@15.214,23.49
LEDs.GPIO8: M1.48 Q4.5 R81.2 | length 56.9
  Top Layer w0.15: M1.48@24,65.6 23.995,65.595 23.995,64.588 23.975,64.567 23.975,64.158 24.366,63.768 25.122,63.768 25.23,63.875 26.725,63.875 v1(26.8,63.8)
  L1-Signal w0.15: v1(15.214,21.377) 15.214,21.94 16.05,22.776 16.05,26.3 17.75,28 17.75,30.1 18.3,30.65 18.3,33.074 22.076,36.85 23.388,36.85 25.65,39.112 25.65,53.673 24.075,55.248 24.075,55.767 24.958,56.65 26.1,56.65 27.725,58.275 27.725,62.875 v1(26.8,63.8)
  Bottom Layer w0.15: Q4.5@15.214,22.14 v1(15.214,21.377) 15.214,20.615 R81.2@15.314,20.515
MPCI1_1V5: C180.2 J8.6 J8.28 J8.48 R149.2 U32.6 X55.1 | length 11.7
  Top Layer w0.15: R149.2@36.55,55.05 36.587,55.013 36.987,55.013 37.45,54.55 C180.2@38.15,54.55 ; 38.15,53.825 39.89,53.825 X55.1@40.865,52.85
  Top Layer w0.5: U32.6@37.8,52.3 v1(37.8,53.475) 38.15,53.825 C180.2@38.15,54.55
  Bottom Layer w0.25: v1(49.6,79.95) J8.48@49.6,81.4
  Bottom Layer w0.5: J8.6@29.6,81.4 v1(29.6,82.85) ; J8.28@41.6,81.4 v1(41.6,82.85)
MPCI1_3V3: C168.1 C169.1 C170.2 C171.2 C172.2 C174.2 J8.2 J8.24 J8.39 J8.41 J8.52 L27.2 L28.2 L30.2 R135.2 R141.1 R146.1 R151.2 R152.2 R153.2 U32.2 U32.3 | length 33.3
  Top Layer w0.25: R135.2@43.7,99.2 43.7,98.525 44.808,97.417 45.323,97.417 v1(45.39,97.35) ; v1(45.4,98.5) R151.2@45.4,99.2 ; v1(46.8,98.5) R152.2@46.8,99.2 ; v1(48.3,98.5) R153.2@48.3,99.2
  Top Layer w0.5: L28.2@31.96,53.654 L27.2@31.96,55.054 ; U32.2@36.53,47.3 36.649,47.181 36.649,46.237 36.753,46.133 37.769,46.133 ; C174.2@37.769,45.271 37.769,46.133 ; C174.2@37.79,45.25 v1(38.765,45.25) ; U32.3@37.8,47.3 37.769,47.269 37.769,46.133 ; v1(50.8,98) L30.2@50.8,98.86
  L4-Signal w0.25: v1(45.39,97.35) 45.395,97.355 45.395,98.495 v1(45.4,98.5) v1(46.8,98.5) v1(48.3,98.5) 49.12,99.32 50.18,99.32 50.8,98.7 v1(50.8,98)
  Bottom Layer w0.25: v1(27.09,81.4) J8.2@28,81.4 ; v1(37.6,78.3) 37.608,78.308 38.332,78.308 R141.1@38.34,78.316 ; R141.1@38.356,78.3 R146.1@39.3,78.3 ; v1(45.75,92.2) 45.75,92.105 45.825,92.03 45.825,91.625 45.95,91.5 C172.2@46,91.5 J8.39@46,89.6 ; v1(46.5,87.8) 46.5,87.895 46.8,88.195 J8.41@46.8,89.6
  Bottom Layer w0.5: J8.24@40,81.4 40,80.15 40.2,79.95 C171.2@40.2,79.4 40.25,79.4 40.25,79.095 40.581,78.764 40.581,78.669 v1(40.6,78.65) ; v1(50.45,79.5) C170.2@51.2,79.5 J8.52@51.2,81.4
  other v1: 31,52.85 31,55.05
NetC2_2: C2.2 J10.S R3.1 | length 15.8
  Bottom Layer w0.5: J10.S@61.3,10.269 70.019,10.269 R3.1@70.05,10.3 70.081,10.269 J10.S@77.05,10.269
NetC3_3: C3.3 L2.1 | length 2.1
  Top Layer w0.75: C3.3@87.15,55.2 L2.1@87.15,57.3
NetC22_2: C22.2 U8.55 Y1.1 | length 5.2
  Bottom Layer w0.15: C22.2@22.8,25.6 22.8,24.375 23.425,24.375 24.053,23.747 U8.55@26.564,23.747
NetC23_2: C23.2 U8.54 Y1.3 | length 6.3
  Bottom Layer w0.15: C23.2@21.8,21.9 Y1.3@21.8,23.025 21.8,23.05 22.225,23.475 22.225,23.493 22.357,23.625 23.751,23.625 23.928,23.447 25.703,23.447 25.803,23.347 U8.54@26.564,23.347
NetC28_2: C28.2 R14.1 U8.31 | length 4.7
  Bottom Layer w0.15: U8.31@34.459,23.747 35.003,23.747 35.373,23.377 35.373,21.573 35.2,21.4 C28.2@35.2,20.7 R14.1@36.1,20.7
NetC58_2: C58.2 L6.2 U9.3 | length 6.7
  Top Layer w0.5: C58.2@31.45,44.15 C58.2@31.458,44.15 ; U9.3@31.465,42.05 31.458,42.057 C58.2@31.458,44.15 ; 32.75,44.15 C58.2@31.458,44.15
  Top Layer w0.75: 32.75,44.15 33.65,45.05 L6.2@33.65,47.1
NetC64_2: C64.2 C65.2 R22.1 R23.2 U8.19 | length 12.7
  Top Layer w0.15: v1(35.45,28.75) 35.85,28.35 37.7,28.35 38.8,29.45 R22.1@38.85,29.45
  Top Layer w0.5: R23.2@33.15,32.3 34.25,32.3 34.7,31.85 C65.2@36.25,31.85 C64.2@37.1,31.85 37.65,31.85 38.85,30.65 R22.1@38.85,29.45
  Bottom Layer w0.15: U8.19@34.459,28.547 35.247,28.547 v1(35.45,28.75)
NetC67_3: C67.3 L8.1 | length 2.1
  Top Layer w1: L8.1@84.593,79.9 C67.3@86.65,79.9
NetC68_3: C68.3 L9.1 | length 2.5
  Top Layer w1: C68.3@55.875,47.9 L9.1@58.325,47.9
NetC69_3: C69.3 L10.1 | length 10.3
  Top Layer w1.2: L10.1@86.05,27.4 86.05,23.05 88.6,20.5 C69.3@88.6,18.15
NetC70_2: C70.2 C72.2 C75.2 C76.2 C78.2 C79.2 L10.2 R30.2 U12.2
NetC71_2: C71.2 C74.2 L8.2 U10.7 | length 9.4
  Top Layer w0.25: 86.998,71.45 87.104,71.45 87.25,71.304 U10.7@87.25,69.675
  Top Layer w1: L8.2@84.593,76.7 86.725,76.7 86.725,74.8 86.725,71.975 86.998,71.702 86.998,71.45
NetC73_2: C73.2 C77.2 L9.2 R28.2 U11.2 | length 11.1
  Top Layer w0.25: R28.2@59.765,42.075 61.225,42.075 C73.2@61.5,41.8
  Top Layer w0.75: U11.2@61.035,38.9 61.035,40.635 61.5,41.1 C73.2@61.5,41.8 61.513,41.813 61.513,47.887 L9.2@61.525,47.9
NetC80_1: C80.1 D2.2 | length 5.6
  Top Layer w1.25: D2.2@80.95,14.028 83.442,14.028 84.628,12.842 84.628,11.422 C80.1@84.65,11.4
NetC80_3: C80.3 L12.1 | length 3.5
  Top Layer w0.8: C80.3@88.35,11.4 90.12,11.4 90.8,10.72 L12.1@91.59,10.72
NetC81_1: C81.1 R35.1 | length 1.5
  Top Layer w0.15: R35.1@59.4,30.7 59.4,30.1 59.588,29.912 59.588,29.412 C81.1@59.7,29.3
NetC82_1: C82.1 U11.1 | length 2.9
  Top Layer w0.25: U11.1@62.305,38.9 62.305,38.549 62.581,38.273 63.253,38.273 63.625,37.901 C82.1@63.625,36.9
NetC82_2: C82.2 L13.1 U11.8 | length 8.2
  Top Layer w0.25: U11.8@62.305,33.9 62.305,34.252 62.581,34.528 63.178,34.528 63.625,34.975 C82.2@63.625,35.9
  Top Layer w0.75: U11.8@62.305,33.9 62.305,32.395 63.4,31.3 L13.1@63.4,29
NetC83_1: C83.1 R37.1 R38.2 U10.2 | length 3.4
  Top Layer w0.25: R38.2@86,66.95 R37.1@86.998,66.95 ; R37.1@86.998,66.946 87,66.948 88.02,66.948 C83.1@88.023,66.95 ; R37.1@87.062,67.012 87.062,67.625 87.25,67.813 U10.2@87.25,68.325
NetC84_1: C84.1 R35.2 U11.6 | length 4.8
  Top Layer w0.15: U11.6@59.765,33.9 59.765,32.765 59.4,32.4 R35.2@59.4,31.7 59.9,31.7 60.35,31.25 60.35,30.925 61.05,30.225 C84.1@61.05,30.2
NetC85_1: C85.1 D3.3 L14.1 R42.2 U12.8 | length 9.8
  Top Layer w0.3: D3.3@81.7,47.6 81.9,47.4 84.775,47.4 R42.2@84.775,49
  Top Layer w0.4: U12.8@80.395,43.6 80.395,46.295 D3.3@81.7,47.6
  Top Layer w0.75: D3.3@81.343,47.957 D3.3@81.7,47.6
NetC85_2: C85.2 U12.7 | length 4.6
  Top Layer w0.25: U12.7@81.665,43.6 81.665,44.815 81.85,45 83.35,45 84,45.65 C85.2@84.725,45.65
NetC87_1: C87.1 R39.1 R40.2 U11.5 | length 5.1
  Top Layer w0.15: R39.1@58.15,31.7 57,31.7 C87.1@56.9,31.6 56.9,33.05 57,33.15 R40.2@57,33.9 U11.5@58.495,33.9
NetC90_1: C90.1 R44.1 R45.2 U12.5 | length 6.1
  Top Layer w0.25: U12.5@84.205,43.6 87,43.6 R44.1@87.1,43.5 87.1,43.6 87.1,44.2 86.3,45 C90.1@86.3,46.35
NetC90_2: C90.2 C93.1 R42.1 | length 3.6
  Top Layer w0.15: R42.1@85.775,49 85.817,48.958 85.817,48.563 86.3,48.08 C90.2@86.3,47.35 87.925,47.35 C93.1@87.975,47.4
NetC104_2: C104.2 L15.2 U14.1 | length 3.4
  Bottom Layer w0.5: U14.1@7.36,30.5 7.36,32.035 7.185,32.21 L15.2@8.85,32.21
NetC106_2: C106.2 L16.2 U13.12 | length 2.5
  Bottom Layer w0.15: C106.2@17.05,48.5 U13.12@18.25,48.5 18.25,47.29 L16.2@18.16,47.2
NetC109_2: C109.2 J4.SH1 J4.SH2 J4.SH3 J4.SH4 R66.1 | length 18.6
  Bottom Layer w0.5: J4.SH4@2.595,43.53 J4.SH4@2.82,43.53 ; J4.SH2@6.775,43.53 J4.SH4@2.82,43.53 ; J4.SH1@6.775,52.17 J4.SH3@2.595,52.17 2.995,52.17 3.245,51.92 3.245,51.52 4.35,50.415 R66.1@4.35,49.15 4.35,46.85 4.093,46.593 4.093,45.393 3.07,44.37 3.07,43.78 J4.SH4@2.82,43.53
NetC127_2: C127.2 R91.1 R92.1 U22.5 | length 25
  Top Layer w0.25: v1(117,10.3) 117,9.343 115.65,7.993 115.65,7.1 117.053,5.697 117.053,2.097 118.7,0.45 121.4,0.45 121.65,0.7 v1(121.65,1.5) 121.648,1.502 U22.5@120.163,1.502
  Bottom Layer w0.25: R91.1@111.8,11.55 112.55,11.55 113.14,10.96 116.34,10.96 v1(117,10.3)
  Bottom Layer w0.5: C127.2@120.7,1.45 121.584,1.45 121.634,1.5 v1(121.65,1.5) 121.65,1.595 121.567,1.678 R92.1@121.567,2.776
NetC128_2: C128.2 R90.2 R93.1 U23.5 | length 17.2
  Top Layer w0.25: R93.1@107.6,21.862 v1(107.6,20.95) 106.6,19.95 106.6,17.696 107.906,16.39 U23.5@109.261,16.39 109.25,16.379 C128.2@109.25,15.15
  Bottom Layer w0.25: R90.2@100.7,24 101.45,24 102.1,23.35 105.2,23.35 v1(107.6,20.95)
NetC131_2: C131.2 R95.1 R97.1 | length 3.2
  Bottom Layer w0.15: C131.2@110.4,23.8 110.8,24.2 R95.1@113.45,24.2
NetC132_2: C132.2 R94.1 R96.1 | length 3.7
  Bottom Layer w0.15: R94.1@119.75,10.3 R96.1@121.5,10.3 ; R96.1@121.5,10.285 121.8,9.985 C132.2@121.8,8.5
NetC139_2: C139.2 R119.2 Y2.1 | length 2.8
  Bottom Layer w0.15: C139.2@39.975,21.425 Y2.1@39.975,22.85 ; C139.2@40,21.4 40,20.7 40,20.65 40.425,20.225 R119.2@40.475,20.225
NetC142_2: C142.2 U26.15 Y2.3 | length 6.5
  Bottom Layer w0.15: C142.2@41.8,26.7 41.8,25.05 42.678,24.172 42.678,22.572 42.925,22.325 U26.15@44.6,22.325
NetC156_2: C156.2 R122.1 U26.12 | length 5.2
  Bottom Layer w0.15: C156.2@42.25,17.8 R122.1@42.25,19 42.25,19.05 43.2,19.05 43.953,19.803 44.903,19.803 45.25,20.15 U26.12@45.25,20.675
NetC158_2: C158.2 C159.2 L26.2 U29.3 U30.3 | length 12.9
  Bottom Layer w0.5: U29.3@58.4,26.9 58.4,29.35 59.008,29.958 64.194,29.958 64.34,29.812 L26.2@64.34,28.91 ; L26.2@64.44,28.9 64.46,28.88 C159.2@65.77,28.88 U30.3@65.77,26.9
NetC163_2: C163.2 J7.S R131.1 | length 16.2
  Bottom Layer w0.5: J7.S@41.06,10.319 43.931,10.319 44.45,9.8 R131.1@47.45,9.8 C163.2@49.85,9.8 52.65,9.8 53.169,10.319 J7.S@56.81,10.319
NetC167_2: C167.2 L29.2 U31.2 | length 2.5
  Top Layer w0.25: L29.2@58.615,101.225 L29.2@58.65,101.19
  Top Layer w0.4: U31.2@56.12,101.225 L29.2@58.615,101.225
NetC173_2: C173.2 L30.1 R134.1 R136.2 R137.2 | length 7.8
  Top Layer w0.15: R137.2@51.6,103.95 51.125,103.475 51.125,103.075 R136.2@50.9,102.85 50.15,102.1 50.15,101.06 50.77,100.44 L30.1@50.8,100.44 51.185,100.055 51.695,100.055 51.95,99.8 C173.2@51.95,99.35 52.95,99.35 R134.1@53.3,99
NetC175_2: C175.2 J8.8 J9.C1 R139.2 U33.5 | length 41.2
  Top Layer w0.15: v1(18.75,83.3) 22.6,83.3 v1(23.9,82)
  Bottom Layer w0.15: J9.C1@1.655,74.19 1.655,74.34 2.715,75.4 3,75.4 6.716,79.116 15.966,79.116 16.55,79.7 18.637,79.7 18.75,79.813 v1(18.75,83.3) ; v1(23.9,82) 24.7,82 26.15,83.45 30.1,83.45 30.4,83.15 J8.8@30.4,81.4 C175.2@30.4,79.7 30.4,78.85 30.65,78.6 R139.2@31.3,78.6
NetC176_2: C176.2 R138.1 U32.4 | length 3.6
  Top Layer w0.3: U32.4@39.07,47.3 C176.2@40.865,47.3 R138.1@40.865,49.07
NetC177_2: C177.2 J8.10 J9.C7 R139.1 U33.1 | length 34.6
  Bottom Layer w0.15: J9.C7@13.245,69.11 13.245,70.445 12.3,71.39 12.3,75.45 14.15,77.3 18.45,77.3 19.41,78.26 19.41,80.26 19.667,80.517 20.272,80.517 U33.1@20.405,80.65 21.25,80.65 21.7,81.1 21.7,81.95 21.975,82.225 21.975,82.25 22.375,82.65 C177.2@22.4,82.65 24.55,82.65 25.65,83.75 30.6,83.75 31.2,83.15 J8.10@31.2,81.4 31.3,81.3 R139.1@31.3,79.6
NetC178_2: C178.2 J8.12 J9.C3 U33.4 | length 43.1
  Bottom Layer w0.15: J9.C3@1.655,69.11 1.655,70.195 2.6,71.14 2.6,74.25 4.111,75.761 8.661,75.761 11.65,78.75 U33.4@17.895,78.75 18.7,78.75 19.05,79.1 19.05,82.648 19.752,83.35 21.65,83.35 21.975,83.675 21.975,83.7 22.375,84.1 C178.2@22.4,84.1 25.126,84.1 25.176,84.05 30.9,84.05 32,82.95 J8.12@32,81.4
NetC179_2: C179.2 J8.14 J9.C2 U33.6 | length 43.9
  Bottom Layer w0.15: J9.C2@1.655,71.65 1.655,71.8 0.9,72.555 0.9,74.65 2.334,76.084 2.884,76.084 6.45,79.65 15.35,79.65 16.35,80.65 U33.6@17.895,80.65 17.895,83.395 19.35,84.85 21.7,84.85 21.975,85.125 21.975,85.15 22.375,85.55 C179.2@22.4,85.55 24.1,85.55 25.3,84.35 31.3,84.35 32.8,82.85 J8.14@32.8,81.4
NetC181_2: C181.2 L31.2 R154.2 U35.1 | length 6.5
  Bottom Layer w0.5: L31.2@14.01,31.05 14.026,31.034 U35.1@14.026,29.631 16.181,29.631 C181.2@16.2,29.65 ; C181.2@16.25,29.65 16.25,28.943 16.543,28.65 17.107,28.65 17.4,28.357 17.4,28 17.65,27.75 R154.2@17.7,27.75
NetC182_2: C182.2 J12.4 U34.5 U34.6 U35.6 X57.1 | length 27.3
  Top Layer w0.5: J12.4@4.303,34.985 5.703,34.985 5.988,34.7 6.99,34.7 8.75,36.46 8.75,39.9 v1(9.5,40.65)
  Bottom Layer w0.25: v1(9.5,40.65) 11.162,38.987 U34.6@13.008,38.987 U34.5@13.842,38.987 13.842,38.542 13.3,38 12.9,38 10.85,35.95 10.85,31.728 11.5,31.078 X57.1@11.5,31 X57.1@11.516,30.984 ; U35.6@11.497,29.65 U35.6@11.516,29.631
  Bottom Layer w0.5: C182.2@10.2,29.65 U35.6@11.497,29.65 ; U35.6@11.516,29.631 X57.1@11.516,30.984
NetC185_1: C185.1 R161.2 U39.7 | length 4.6
  Bottom Layer w0.15: U39.7@105.625,55.75 105.625,54.575 105.35,54.3 C185.1@105.3,54.3 105.3,53.888 105.388,53.8 107.077,53.8 107.252,53.625 107.492,53.625 R161.2@107.717,53.4
NetC185_2: C185.2 R160.2 U39.6 | length 2.9
  Bottom Layer w0.15: U39.6@106.275,55.75 106.275,54.325 C185.2@106.3,54.3 R160.2@107.71,54.3
NetC186_1: C186.1 JP1.2 RA6.5 RA6.8 U39.10 | length 19.4
  Bottom Layer w0.15: U39.10@105.625,62.25 105.625,63.825 105.95,64.15 105.95,64.25 105.775,64.425 105.475,64.725 105.475,65.775 105.915,66.215 106.15,66.215 106.688,66.753 109.254,66.753 109.407,66.6 110.95,66.6 112,65.55 112,63.2 112.3,62.9 RA6.5@112.9,62.9 113.75,62.9 ; RA6.8@112.9,60.5 113.409,60.5 113.75,60.841 113.75,62.9 ; JP1.2@114.6,62.9 113.75,62.9
NetC186_2: C186.2 RA6.4 RA6.6 U39.11 | length 14.4
  Bottom Layer w0.15: U39.11@106.275,62.25 106.275,63.457 106.425,63.607 106.425,64.675 105.95,65.15 C186.2@105.95,65.2 105.996,65.246 105.996,65.637 106.812,66.453 109.097,66.453 109.25,66.3 110.826,66.3 111.3,65.826 RA6.4@111.3,62.9 111.434,62.766 111.834,62.766 112.35,62.25 112.75,62.25 RA6.6@112.9,62.1
NetC187_1: C187.1 R163.2 U40.7 | length 4.7
  Bottom Layer w0.15: U40.7@105.625,79.1 105.625,77.925 105.35,77.65 C187.1@105.3,77.65 105.3,77.15 105.5,76.95 107.05,76.95 107.25,76.75 R163.2@107.717,76.75
NetC187_2: C187.2 R162.2 U40.6 | length 2.9
  Bottom Layer w0.15: U40.6@106.275,79.1 106.275,77.675 C187.2@106.3,77.65 R162.2@107.71,77.65
NetC188_1: C188.1 JP2.2 RA7.5 RA7.8 U40.10 | length 19.1
  Bottom Layer w0.15: U40.10@105.625,85.6 105.625,87.175 105.95,87.5 C188.1@105.95,87.55 105.95,87.6 105.475,88.075 105.475,88.943 106.635,90.103 109.257,90.103 109.357,90.003 110.627,90.003 111.7,88.93 111.7,86.654 112.204,86.15 RA7.5@112.7,86.15 113.55,86.15 ; RA7.8@112.7,83.75 113.209,83.75 113.55,84.091 113.55,86.15 ; JP2.2@114.4,86.15 113.55,86.15
NetC188_2: C188.2 RA7.4 RA7.6 U40.11 | length 14.3
  Bottom Layer w0.15: U40.11@106.275,85.6 106.275,86.807 106.425,86.957 106.425,88.025 105.95,88.5 105.95,88.994 106.759,89.803 109.132,89.803 109.233,89.703 110.503,89.703 111.1,89.106 RA7.4@111.1,86.15 111.234,86.016 111.634,86.016 112.15,85.5 112.55,85.5 RA7.6@112.7,85.35
NetC189_2: C189.2 R164.2 R166.2 U42.4 | length 4.1
  Bottom Layer w0.25: U42.4@108.07,96.269 109.669,96.269 R166.2@109.7,96.3 C189.2@109.7,95.35 109.75,95.35 110.2,94.9 110.2,94.75 R164.2@110.7,94.25
NetC190_2: C190.2 R165.2 R167.2 U41.4 | length 4.1
  Bottom Layer w0.25: U41.4@108.13,72.884 109.729,72.884 R167.2@109.76,72.915 109.76,71.965 109.81,71.965 110.26,71.515 110.26,71.365 R165.2@110.76,70.865
NetC234_1: C234.1 U56.3 | length 3.2
  Top Layer w0.15: U56.3@110.775,44.093 112.043,44.093 112.3,44.35 112.3,44.668 112.775,45.143 112.8,45.143 113.2,45.543 C234.1@113.2,45.568
NetC234_2: C234.2 U56.1 | length 2.9
  Top Layer w0.15: U56.1@110.775,42.793 112.125,42.793 112.775,43.443 112.8,43.443 113.2,43.843 C234.2@113.2,43.868
NetC235_1: C235.1 U56.5 | length 5.1
  Top Layer w0.15: U56.5@110.775,45.393 111.793,45.393 111.95,45.55 111.95,46.35 112.5,46.9 112.5,48.168 112.775,48.443 112.8,48.443 113.2,48.843 C235.1@113.2,48.868
NetC235_2: C235.2 U56.4 | length 4.1
  Top Layer w0.15: U56.4@110.775,44.743 111.893,44.743 112.25,45.1 112.25,46.218 112.775,46.743 112.8,46.743 113.2,47.143 C235.2@113.2,47.168
NetC236_2: C236.2 U56.6 | length 5
  Top Layer w0.15: C236.2@108.9,48.768 108.9,47.45 108.4,46.95 108.4,46.55 108.907,46.043 U56.6@110.775,46.043
NetC238_2: C238.2 U56.2 | length 3.8
  Top Layer w0.15: C238.2@110.75,41.368 110.725,41.368 110.325,41.768 110.325,41.793 109.45,42.668 109.45,43.2 109.693,43.443 U56.2@110.775,43.443
NetC239_2: C239.2 L33.2 U65.3 | length 3.7
  Bottom Layer w0.25: L33.2@13.615,96.15 13.675,96.21 C239.2@13.675,97.547 13.725,97.547 13.85,97.672 13.85,97.675 14.36,98.185 U65.3@15.725,98.185
NetC241_2: C241.2 L34.2 U64.1 | length 3.2
  Bottom Layer w0.5: L34.2@1.05,95.1 4.173,95.1 U64.1@4.195,95.078
NetC245_2: C245.2 J15.22 R209.2 R210.1 | length 12.5
  Top Layer w0.15: J15.22@4.081,85.978 7.822,85.978 8.6,85.2 11.076,85.2 12.3,86.424 R210.1@12.3,87.628 ; C245.2@12.3,88.528 R210.1@12.3,87.628 ; R209.2@13.6,87.65 13.578,87.628 R210.1@12.3,87.628
NetC253_2: C253.2 L1.2 L40.2 R223.2 U68.1 | length 8.7
  Top Layer w0.15: v1(17.05,24.325) 17.05,24.3 17.215,24.135 18.412,24.135 18.96,24.683 R223.2@18.96,24.704
  Bottom Layer w0.15: C253.2@17.05,23.725 16.95,23.625 C253.2@17.2,23.375
  Bottom Layer w0.5: C253.2@17.05,23.725 v1(17.05,24.325)
  Bottom Layer w0.6: C253.2@17.2,23.375 17.265,23.31 L1.2@18.95,23.31 ; U68.1@18.661,21.255 18.661,23.022 L1.2@18.95,23.31 ; L40.2@20.311,23.31 L1.2@18.95,23.31
NetC257_2: C257.2 J16.S1 J16.S2 J16.S3 J16.S4 R214.1 | length 14.4
  Bottom Layer w0.5: J16.S1@23.68,8.069 23.853,8.069 25.322,6.6 R214.1@28.65,6.6 C257.2@31.05,6.6 34.45,6.6 35.351,6.6 J16.S4@36.82,8.069
NetD4_1: D4.1 R43.2 | length 2
  Top Layer w0.15: R43.2@83.225,19.35 D4.1@83.225,21.3
NetD5_3: D5.3 R47.2 | length 17.4
  Top Layer w0.15: D5.3@9.45,18.375 9.4,18.375 8.5,19.275 8.5,19.893 6.825,21.568 6.825,24.475 8.1,25.75 15.4,25.75 R47.2@16.15,25
NetD6_1: D6.1 R50.1 | length 3.6
  Top Layer w0.15: D6.1@49,103.425 49.7,102.725 49.7,100.924 49.502,100.725 R50.1@49.502,100.2
NetD7_2: D7.2 R72.2 | length 13.8
  Top Layer w0.15: v1(4.05,18.7) 3.964,18.614 3.964,18.364 2.65,17.05 2.65,14.95 5.65,11.95 7.925,11.95 9.4,10.475 D7.2@9.45,10.475
  Bottom Layer w0.15: v1(4.05,18.7) R72.2@4.05,19.5
NetD7_3: D7.3 R69.2 | length 12.3
  Top Layer w0.15: v1(3.15,18.7) 3.15,18.25 2.35,17.45 2.35,14.55 6.425,10.475 D7.3@7.65,10.475
  Bottom Layer w0.15: v1(3.15,18.7) R69.2@3.15,19.5
NetD7_4: D7.4 R68.2 | length 13.3
  Top Layer w0.15: v1(1.9,17.8) 1.9,14.3 6.925,9.275 D7.4@7.65,9.275
  Bottom Layer w0.15: R68.2@1.35,19.5 1.35,18.25 1.8,17.8 v1(1.9,17.8)
NetD8_2: D8.2 R77.2 | length 6.7
  Top Layer w0.15: D8.2@9.45,15.025 9.512,15.087 9.512,15.562 11.95,18 12.799,18 v1(13.514,18.715)
  Bottom Layer w0.15: v1(13.514,18.715) R77.2@13.514,19.515
NetD8_3: D8.3 R76.2 | length 7.1
  Top Layer w0.15: D8.3@7.65,15.025 7.65,15.744 9.45,17.544 11.07,17.544 11.714,18.189 v1(11.714,18.715)
  Bottom Layer w0.15: v1(11.714,18.715) R76.2@11.714,19.515
NetD8_4: D8.4 R73.2 | length 7.3
  Top Layer w0.25: v1(6.7,13.812) 7.637,13.812 D8.4@7.65,13.825
  Bottom Layer w0.15: R73.2@5.85,19.5 5.85,18.528 7.1,17.278 7.1,14.212 v1(6.7,13.812)
NetD9_2: D9.2 R83.2 | length 9.8
  Top Layer w0.15: D9.2@9.45,24.125 10.175,24.125 10.964,23.336 10.964,23.036 11.614,22.386 12.514,22.386 15.697,19.203 15.803,19.203 16.156,18.85 v1(16.192,18.85)
  Bottom Layer w0.15: v1(16.192,18.85) 16.192,19.493 R83.2@16.214,19.515
NetD9_3: D9.3 R82.2 | length 4.5
  Top Layer w0.15: D9.3@7.65,24.125 7.7,24.125 8.6,23.225 8.6,21.65 v1(9.1,21.15)
  Bottom Layer w0.15: v1(9.1,21.15) R82.2@10,21.15
NetD9_4: D9.4 R80.2 | length 10.6
  Top Layer w0.15: D9.4@7.65,22.925 7.65,21.45 8.585,20.515 13.414,20.515 14.414,19.515 v1(14.414,18.715)
  Bottom Layer w0.15: v1(14.414,18.715) R80.2@14.414,19.515
NetD10_1: D10.1 R100.2 | length 1.9
  Bottom Layer w0.15: R100.2@62.197,87.149 62.197,88.074 D10.1@62.872,88.749
NetD10_2: D10.2 PR3.2 Q7.3 | length 8.2
  Bottom Layer w0.15: Q7.3@59.447,86.699 59.522,86.699 60.314,87.49 60.621,87.49 60.804,87.674 60.81,87.674 60.897,87.761 60.897,88.424 61.228,88.754 61.76,88.754 62.454,89.449 64.211,89.449 64.825,88.835 64.825,88.785 65.5,88.11 PR3.2@65.55,88.11
NetD11_1: D11.1 R101.2 | length 1.9
  Bottom Layer w0.15: R101.2@62.197,92.749 62.197,93.674 D11.1@62.872,94.349
NetD11_2: D11.2 PR4.2 Q8.3 | length 8.7
  Bottom Layer w0.15: Q8.3@59.447,92.249 59.447,93.48 60.316,94.349 D11.2@61.222,94.349 61.922,95.049 63.971,95.049 64.825,94.195 64.825,94.145 65.5,93.47 PR4.2@65.55,93.47
NetD12_1: D12.1 R98.2 | length 1.9
  Bottom Layer w0.15: R98.2@62.297,76.449 62.297,77.374 D12.1@62.972,78.049
NetD12_2: D12.2 PR1.2 Q5.3 | length 8.1
  Bottom Layer w0.15: Q5.3@59.547,75.949 59.872,76.274 59.872,76.599 D12.2@61.322,78.049 62.264,78.99 64.03,78.99 64.825,78.195 64.825,78.145 65.5,77.47 PR1.2@65.55,77.47
NetD13_1: D13.1 R99.2 | length 1.9
  Bottom Layer w0.15: R99.2@62.197,81.849 62.197,82.774 D13.1@62.872,83.449
NetD13_2: D13.2 PR2.2 Q6.3 | length 8.4
  Bottom Layer w0.15: Q6.3@59.447,81.349 59.66,81.561 59.66,82.1 59.85,82.29 60.5,82.29 60.897,82.688 60.897,83.124 61.228,83.454 61.76,83.454 62.454,84.149 64.211,84.149 64.825,83.535 64.825,83.485 65.5,82.81 PR2.2@65.55,82.81
NetD18_1: D18.1 R135.1 | length 3.5
  Top Layer w0.18: D18.1@43,103.425 43.7,102.725 R135.1@43.7,100.2
NetD19_1: D19.1 R148.1 | length 35.3
  Top Layer w0.25: v1(47.62,47.6) D19.1@48.55,47.6
  L1-Signal w0.15: v1(38.15,76.9) 39.6,75.45 39.6,68.75 47.625,60.725 47.625,49.765 47.62,49.76 v1(47.62,47.6)
  Bottom Layer w0.15: v1(38.15,76.9) R148.1@39.25,76.9
NetD20_1: D20.1 R151.1 | length 3.6
  Top Layer w0.18: D20.1@44.5,103.425 45.2,102.725 45.2,101.436 45.4,101.236 R151.1@45.4,100.2
NetD20_2: D20.2 J8.42 | length 22.8
  Top Layer w0.15: D20.2@44.5,101.775 44.5,98.658 45.183,97.975 46.025,97.975 48.15,95.85 48.15,87.2 47.2,86.25 v1(47.2,83.1)
  Bottom Layer w0.15: J8.42@47.2,81.4 v1(47.2,83.1)
NetD21_1: D21.1 R152.1 | length 3.6
  Top Layer w0.18: D21.1@46,103.425 46.8,102.625 R152.1@46.8,100.2
NetD21_2: D21.2 J8.44 | length 21.6
  Top Layer w0.15: D21.2@46,101.775 46,98.475 48.45,96.025 48.45,86.8 48,86.35 v1(48,83.75)
  Bottom Layer w0.15: J8.44@48,81.4 v1(48,83.75)
NetD22_1: D22.1 R153.1 | length 3.6
  Top Layer w0.18: D22.1@47.5,103.425 48.3,102.625 R153.1@48.3,100.2
NetD22_2: D22.2 J8.46 | length 20.9
  Top Layer w0.15: D22.2@47.5,101.775 47.5,97.4 48.8,96.1 v1(48.8,83.25)
  Bottom Layer w0.15: J8.46@48.8,81.4 v1(48.8,83.25)
NetD29_3: D29.3 R195.2 U60.5 | length 3.6
  Top Layer w0.15: D29.3@90.355,81.948 90.367,81.961 90.367,82.561 90.905,83.098 R195.2@90.905,83.848 U60.5@90.905,85.298
NetD30_3: D30.3 R196.2 U61.5 | length 3.6
  Top Layer w0.15: D30.3@83.425,81.925 83.462,81.962 83.462,82.537 83.975,83.05 R196.2@83.975,83.8 U61.5@83.975,85.25
NetD33_2: D33.2 R219.2 S1.2 | length 6.8
  Top Layer w0.25: S1.2@13.9,3.075 13.857,3.118 D33.2@13.857,4.8 13.857,5.707 v1(14.05,5.9)
  Bottom Layer w0.15: v1(14.05,5.9) R219.2@14.05,9.825
NetD34_2: D34.2 R218.2 S2.2 | length 9
  Top Layer w0.25: v1(18.2,7.1) 19.607,5.693 D34.2@19.607,4.8 19.6,4.793 S2.2@19.6,3.075
  Bottom Layer w0.15: R218.2@15.55,9.825 16.55,9.825 18.2,8.175 v1(18.2,7.1)
NetJ7_12: J7.12 R123.2 | length 26.5
  Bottom Layer w0.15: J7.12@44.845,3.209 46.554,1.5 56.8,1.5 58.986,3.686 58.986,12.064 57.85,13.2 R123.2@57.85,13.95
NetJ7_14: J7.14 R124.2 | length 12.8
  Bottom Layer w0.15: J7.14@55.565,3.209 58.65,6.294 58.65,11.45 56.85,13.25 R124.2@56.85,13.95
NetJ8_1: J8.1 R132.2 R133.2 | length 74.1
  Top Layer w0.15: v1(27.6,88.109) 28.805,89.314 44.786,89.314 45.9,88.2 45.9,83.95 45.875,83.925 45.875,82.625 47.7,80.8 50.317,80.8 53.134,77.984 53.134,76.966 55.95,74.15 67.1,74.15 69.2,76.25 81.506,76.25 82.05,75.706 82.05,74.9 83.05,73.9 84.85,73.9 85.15,73.6 R132.2@85.15,71.7
  Bottom Layer w0.25: v1(27.6,88.109) J8.1@27.6,89.6
NetJ8_16: J8.16 J9.C6 U33.3 | length 29.5
  Bottom Layer w0.15: J9.C6@13.245,71.65 12.738,71.65 12.65,71.738 12.65,74.891 13.459,75.7 17.87,75.7 20.405,78.235 U33.3@20.405,78.75 27.8,78.75 28.5,78.05 32.3,78.05 33.6,79.35 J8.16@33.6,81.4
NetJ8_20: J8.20 R141.2 | length 2.1
  Bottom Layer w0.15: R141.2@38.34,79.316 38.34,81.34 J8.20@38.4,81.4
NetJ8_30: J8.30 R142.2 R145.2 | length 9.2
  Bottom Layer w0.15: J8.30@42.4,81.4 42.4,80.1 43.6,78.9 43.9,78.9 45.425,77.375 45.425,75.825 45,75.4 R145.2@44.95,75.4 R142.2@44.95,73.9
NetJ8_32: J8.32 R143.2 R144.2 | length 12.4
  Bottom Layer w0.15: J8.32@43.2,81.4 43.2,79.95 43.75,79.4 44.25,79.4 45.95,77.7 45.95,73.35 45,72.4 R143.2@44.95,72.4 R144.2@44.95,70.9
NetJ10_12: J10.12 R1.1 | length 19.1
  Bottom Layer w0.15: J10.12@65.085,3.159 66.644,1.6 81.35,1.6 82,2.25 R1.1@82,3.5
NetJ10_14: J10.14 R2.1 | length 4.3
  Bottom Layer w0.25: J10.14@75.805,3.159 76.14,3.494 76.82,3.494 76.826,3.5 R2.1@79.95,3.5
NetJ14_1: J14.1 R190.2 | length 1.6
  Top Layer w0.15: R190.2@111.563,35.228 112.178,35.228 J14.1@112.9,35.95
NetJ18_1: J18.1 R94.2 | length 5.1
  Bottom Layer w0.15: J18.1@117.4,8.285 118.141,9.026 118.141,11.091 119.05,12 R94.2@119.75,12
NetJ19_1: J19.1 R96.2 | length 6.1
  Bottom Layer w0.15: J19.1@120,8.285 118.85,9.435 118.85,10.768 119.232,11.15 120.715,11.15 121.3,11.735 R96.2@121.3,12
NetJ20_1: J20.1 R95.2 | length 3.2
  Bottom Layer w0.15: R95.2@113.45,22.5 113.45,22.45 112.95,21.95 112.95,21 113.542,20.408 113.605,20.408 113.843,20.17 J20.1@114.1,20.17
NetJ21_1: J21.1 R97.2 | length 2.8
  Bottom Layer w0.15: J21.1@111.7,20.17 112.45,20.92 112.45,21.95 111.95,22.45 R97.2@111.95,22.5
NetL11_1: L11.1 U10.6 | length 2.6
  Top Layer w0.25: U10.6@87.748,69.675 87.748,69.894 87.75,69.896 87.75,70.674 87.773,70.697 87.773,70.821 88.3,71.347 L11.1@88.3,72.046
NetL17_1: L17.1 U14.6 | length 1.7
  Bottom Layer w0.5: U14.6@4.85,30.5 L17.1@4.85,32.21
NetL32_1: L32.1 U62.4 U63.4 | length 11.4
  Top Layer w0.25: U63.4@83.325,97.15 83.325,96.023 85.125,94.223 L32.1@87.705,94.223 ; L32.1@87.675,94.223 88.522,94.223 88.925,94.626 88.925,96.783 89.425,97.283 90.17,97.283 U62.4@90.255,97.198
NetM1_187: M1.187 R4.2 | length 6.9
  Top Layer w0.15: v1(60.75,55.95) M1.187@60.75,57.4
  Bottom Layer w0.15: v1(60.75,55.95) 61.6,55.95 61.625,55.975 63.625,55.975 65.1,54.5 R4.2@65.1,54.05
NetM1_254: M1.254 R5.2 | length 9
  Top Layer w0.15: M1.254@77.5,65.6 77.5,66.776 77.724,67 80.15,67 82.25,69.1 82.25,69.85 82.6,70.2 R5.2@83.45,70.2
NetM1_256: M1.256 R6.2 | length 7.3
  Top Layer w0.15: M1.256@78,65.6 78,66.612 78.088,66.7 80.274,66.7 82.224,68.65 R6.2@83.45,68.65
NetPR1_1: PR1.1 R102.2 | length 2.6
  Bottom Layer w0.15: R102.2@62.997,74.849 65.468,74.849 PR1.1@65.55,74.93
NetPR1_4: PR1.4 R110.2 | length 4
  Bottom Layer w0.15: R110.2@78.205,74.93 R110.2@78.25,74.975
  Bottom Layer w0.5: PR1.4@74.25,74.93 R110.2@78.205,74.93
NetPR2_1: PR2.1 R103.2 | length 2.7
  Bottom Layer w0.15: R103.2@62.897,80.249 65.528,80.249 PR2.1@65.55,80.27
NetPR2_4: PR2.4 R111.2 | length 11.1
  Bottom Layer w0.5: PR2.4@74.25,80.27 75.78,80.27 76.55,79.5 79.2,79.5 82.25,76.45 R111.2@82.25,74.975
NetPR3_1: PR3.1 R104.2 | length 2.7
  Bottom Layer w0.15: R104.2@62.897,85.549 65.528,85.549 PR3.1@65.55,85.57
NetPR3_4: PR3.4 R112.2 | length 20.5
  Bottom Layer w0.5: R112.2@71.475,102 71.475,101.171 70.95,100.646 70.243,100.646 69.95,100.354 69.95,87.8 72.18,85.57 PR3.4@74.25,85.57
NetPR4_1: PR4.1 R105.2 | length 2.7
  Bottom Layer w0.15: R105.2@62.897,91.149 65.331,91.149 PR4.1@65.55,90.93
NetPR4_4: PR4.4 R113.2 | length 9
  Bottom Layer w0.5: R113.2@71.475,98 71.475,92.325 72.87,90.93 PR4.4@74.25,90.93
NetPTC1_1: PTC1.1 R110.1 | length 2.4
  Bottom Layer w0.5: R110.1@78.25,81.425 PTC1.1@78.25,83.784
NetPTC2_1: PTC2.1 R111.1 | length 2.4
  Bottom Layer w0.5: R111.1@82.25,81.425 PTC2.1@82.25,83.784
NetPTC3_1: PTC3.1 R112.1 | length 2.4
  Bottom Layer w0.5: R112.1@77.925,102 PTC3.1@80.284,102
NetPTC4_1: PTC4.1 R113.1 | length 2.4
  Bottom Layer w0.5: R113.1@77.925,98 PTC4.1@80.284,98
NetQ1_3: Q1.3 R69.1 | length 3.6
  Bottom Layer w0.15: R69.1@3.15,20.5 3.525,20.875 3.525,20.983 3.9,21.358 3.9,22.4 3.25,23.05 Q1.3@3.25,23.475
NetQ1_6: Q1.6 R68.1 | length 2.3
  Bottom Layer w0.15: R68.1@1.35,20.5 1.35,21.733 1.742,22.125 Q1.6@2.25,22.125
NetQ2_3: Q2.3 R73.1 | length 4.1
  Bottom Layer w0.15: Q2.3@5.45,23.475 5.45,22.888 5.594,22.744 6.199,22.744 6.6,22.342 6.6,21.85 6.225,21.475 6.225,20.875 R73.1@5.85,20.5
NetQ2_6: Q2.6 R72.1 | length 1.8
  Bottom Layer w0.15: R72.1@4.05,20.5 4.159,20.609 4.159,20.937 4.292,21.07 4.292,21.535 4.45,21.692 Q2.6@4.45,22.125
NetQ3_3: Q3.3 R77.1 | length 4
  Bottom Layer w0.15: Q3.3@13.114,23.49 13.114,23.415 13.714,22.815 13.964,22.815 14.325,22.454 14.325,21.876 13.514,21.065 R77.1@13.514,20.515
NetQ3_6: Q3.6 R76.1 | length 1.8
  Bottom Layer w0.15: R76.1@11.714,20.515 12.089,20.89 12.089,21.582 12.114,21.607 Q3.6@12.114,22.14
NetQ4_3: Q4.3 R83.1 | length 4.4
  L3-Signal w0.15: v1(14.75,22.815) 14.75,22.75 v1(16.2,21.3)
  Bottom Layer w0.15: v1(14.75,22.815) 14.75,22.85 15.5,22.85 15.714,23.064 Q4.3@15.714,23.49 ; v1(16.2,21.3) 16.2,20.529 R83.1@16.214,20.515
NetQ4_6: Q4.6 R80.1 | length 1.7
  Bottom Layer w0.15: R80.1@14.414,20.515 14.414,21.32 14.714,21.62 Q4.6@14.714,22.14
NetQ9_3: Q9.3 Q9.6 R158.2 R160.1 | length 8.6
  Bottom Layer w0.15: R160.1@108.71,54.3 109.908,54.3 111.3,55.692 R158.2@111.3,57.2 111.6,57.2 112.025,57.625 112.025,57.688 112.4,58.063 Q9.6@112.4,58.5 111.813,58.5 111.725,58.588 111.725,59.044 111.344,59.425 111.125,59.425 Q9.3@111.05,59.5
NetQ10_3: Q10.3 Q10.6 R159.2 R162.1 | length 8.2
  Bottom Layer w0.15: R162.1@108.7,77.65 109.997,77.65 111.3,78.953 R159.2@111.3,80.253 111.575,80.253 112,80.678 112,81.478 Q10.6@112.075,81.553 111.547,81.553 111.297,81.803 111.297,82.232 111.047,82.482 110.796,82.482 Q10.3@110.725,82.553
NetQ13_3: Q13.3 R47.1 | length 20.9
  Top Layer w0.15: R47.1@16.15,23.8 19.403,23.8 20.25,22.953 20.25,21.954 21.25,20.954 21.25,14.45 19.35,12.55 18.35,12.55 16.75,10.95 Q13.3@16.75,9.4
NetQ14_3: Q14.3 R123.1 | length 3.1
  Bottom Layer w0.15: Q14.3@57,17.475 57.375,17.475 57.6,17.25 57.6,16.3 57.85,16.05 R123.1@57.85,14.95
NetQ14_6: Q14.6 R124.1 | length 1.5
  Bottom Layer w0.15: Q14.6@56,16.125 56.075,16.05 56.075,15.725 R124.1@56.85,14.95
NetR8_2: R8.2 U3.17 | length 71.6
  L1-Signal w0.15: v1(54.6,27.1) 57.623,27.1 57.999,27.476 57.999,28.649 64.6,35.25 64.6,37.6 70.75,43.75 70.75,51.774 71.9,52.924 71.9,60.85 76.25,65.2 83.45,65.2 84.638,66.388 84.638,68.612 80.975,72.275 v1(77.15,72.275)
  Bottom Layer w0.15: R8.2@54.15,25.5 54.15,26.65 v1(54.6,27.1) ; U3.17@77.15,71.45 v1(77.15,72.275)
NetR12_2: R12.2 U8.21 | length 2.1
  Bottom Layer w0.15: U8.21@34.459,27.747 35.647,27.747 35.95,28.05 R12.2@36.45,28.05
NetR13_2: R13.2 U8.22 | length 2.1
  Bottom Layer w0.15: U8.22@34.459,27.347 35.753,27.347 35.95,27.15 R13.2@36.45,27.15
NetR17_2: R17.2 U8.24 | length 2.5
  Bottom Layer w0.15: U8.24@34.459,26.547 35.128,26.547 36.1,25.575 36.225,25.575 R17.2@36.45,25.35
NetR18_2: R18.2 U8.23 | length 2.3
  Bottom Layer w0.15: U8.23@34.459,26.947 35.403,26.947 36.013,26.337 36.363,26.337 R18.2@36.45,26.25
NetR19_1: R19.1 U8.26 | length 4.7
  Bottom Layer w0.15: U8.26@34.459,25.747 35.353,25.747 35.85,25.25 35.85,25.032 36.057,24.825 36.759,24.825 37.484,24.1 R19.1@38.35,24.1
NetR19_2: R19.2 R20.1 | length 1.7
  Bottom Layer w0.15: R20.1@38.341,20.75 38.341,22.391 R19.2@38.35,22.4
NetR21_1: R21.1 U8.2 | length 3.8
  Top Layer w0.15: R21.1@26.3,31.35 26.475,31.175 v1(26.475,30.6)
  Bottom Layer w0.15: v1(26.475,30.6) 26.475,30.722 26.6,30.847 26.6,30.85 26.875,31.125 27.625,31.125 27.825,30.925 27.825,30.413 27.786,30.374 27.786,30.344 27.738,30.296 27.738,29.722 U8.2@27.711,29.695
NetR24_1: R24.1 R25.2 U9.7 | length 5.7
  Top Layer w0.15: R24.1@32.443,33.65 32.743,33.65 ; U9.7@32.735,37.05 32.735,36.092 33.227,35.6 33.85,35.6 34.05,35.4 34.05,34.296 R25.2@33.404,33.65 32.9,33.65 ; 32.743,33.65 32.9,33.65 ; 32.743,33.65 32.9,33.65
NetR25_1: R25.1 R26.2 | length 1
  Top Layer w0.15: R25.1@34.404,33.65 R26.2@35.404,33.65
NetR28_1: R28.1 R29.1 U11.3 | length 4.1
  Top Layer w0.15: R29.1@58.5,42.5 58.925,42.075 58.925,41.915 R28.1@59.765,41.075 U11.3@59.765,38.9
NetR30_1: R30.1 R31.1 U12.3 | length 3.5
  Top Layer w0.25: U12.3@82.935,38.6 83,38.535 R30.1@83,36.55 84.378,36.55 R31.1@84.4,36.528
NetR32_2: R32.2 U11.4 | length 2.1
  Top Layer w0.15: R32.2@58.175,40.9 58.495,40.58 U11.4@58.495,38.9
NetR33_2: R33.2 R34.2 U12.4 | length 2.5
  Top Layer w0.25: U12.4@84.205,38.6 85.778,38.6 R34.2@85.8,38.578 R33.2@85.8,37.678
NetR36_1: R36.1 R37.2 | length 1.1
  Top Layer w0.25: R37.2@87,65.95 87.075,65.875 87.975,65.875 R36.1@88.05,65.8
NetR41_2: R41.2 R43.1 | length 2.1
  Top Layer w0.25: R43.1@85.275,19.35 85.287,19.338 85.287,17.238 R41.2@85.3,17.225
NetR45_1: R45.1 R46.2 | length 1.1
  Top Layer w0.15: R46.2@85.6,41.478 R45.1@85.6,42.578
NetR59_1: R59.1 R60.2 U13.3 X21.1 | length 4.5
  Bottom Layer w0.15: X21.1@16.6,53 R60.2@16.6,51.4 R59.1@18.2,51.4 ; U13.3@18.25,50 R59.1@18.25,51.35
NetR62_2: R62.2 U14.5 | length 1.4
  Bottom Layer w0.15: R62.2@3.45,29.5 3.5,29.55 U14.5@4.85,29.55
NetR64_2: R64.2 U13.4 | length 2.8
  Bottom Layer w0.15: U13.4@18.65,50 18.65,50.35 18.85,50.55 20.2,50.55 R64.2@20.75,50
NetR86_1: R86.1 U18.5 | length 3.7
  Top Layer w0.25: v1(104.084,7.809) 104.999,7.809 R86.1@105,7.81
  Bottom Layer w0.15: v1@104.084,7.78 105.435,7.78 U18.5@105.45,7.795
  Bottom Layer w0.25: v1@104.085,7.81 U18.5@105.465,7.81
NetR87_1: R87.1 U19.5 | length 2.5
  Bottom Layer w0.15: R87.1@92,20.4 v1(92.75,20.4) 92.872,20.4 93.037,20.235 U19.5@94.35,20.235 U19.5@94.315,20.2
NetR88_2: R88.2 U18.4 | length 2.2
  Bottom Layer w0.25: R88.2@103.3,6.58 103.328,6.552 104.041,6.552 v1(104.069,6.524) ; v1(104.069,6.524) U18.4@105.45,6.525
NetR89_2: R89.2 U19.4 | length 2.4
  Bottom Layer w0.15: R89.2@92,19.1 v1@92.732,19.1 ; v1(92.754,19.122) 92.876,19.122 93.034,18.965 U19.4@94.35,18.965 U19.4@94.315,19
NetR119_1: R119.1 U26.14 | length 3.6
  Bottom Layer w0.15: R119.1@42.175,20.225 42.262,20.312 42.262,21.212 42.875,21.825 U26.14@44.6,21.825
NetR125_1: R125.1 U29.2 U29.4 | length 7
  Top Layer w0.15: v1(57.15,28.15) 59.265,28.15 v1(60.515,26.9)
  Bottom Layer w0.15: U29.2@57.13,26.9 57.15,26.92 v1(57.15,28.15) v1@57.15,28.24 ; U29.4@59.67,26.9 v1(60.515,26.9) R125.1@61.45,26.9
NetR126_1: R126.1 U30.2 U30.4 | length 6.4
  L1-Signal w0.15: v1(65.025,27.978) 65.147,27.978 65.319,28.15 v1(67.035,28.15)
  Bottom Layer w0.15: U30.2@64.5,26.9 64.637,27.037 64.637,27.389 64.939,27.69 64.939,27.892 v1(65.025,27.978) ; v1(67.035,28.15) 67.035,26.905 U30.4@67.04,26.9
  Bottom Layer w0.25: U30.4@67.04,26.9 67.09,26.95 R126.1@68.825,26.95
NetR127_1: R127.1 R128.1 U29.7 | length 3.6
  Bottom Layer w0.25: U29.7@57.13,21.9 57.1,21.87 R128.1@57.1,19.8 57.211,19.689 57.211,19.071 57.333,18.949 57.333,18.582 R127.1@57.465,18.45
NetR129_1: R129.1 R130.1 U30.7 | length 5.6
  Bottom Layer w0.15: R129.1@61.4,19.345 R130.1@61.4,20.65 64.412,20.65 64.5,20.738 U30.7@64.5,21.9